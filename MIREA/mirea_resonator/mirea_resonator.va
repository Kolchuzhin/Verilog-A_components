	I(F1018)<+( -1.0217484823088461e-10*V(reduced_0) +4.1998791202952832e-09*V(reduced_1) -2.0766710151199829e-03*V(F929) -4.5351222575683720e-03*V(F937) +6.3434130089618408e-03*V(F945) -1.1708170078842039e-02*V(F953) +9.0348596504895903e-03*V(F961) -7.3415772101535996e-03*V(F969) +4.6382995415680034e-03*V(F977) -2.8505558381738769e-03*V(F985) -1.1642450107467377e-03*V(F993) +2.3946602765482529e-03*V(F994) -6.2088272101451149e-03*V(F995) +7.3237891210361722e-03*V(F996) -7.0172455515852116e-03*V(F997) +4.8531839038209613e-03*V(F998) -2.3726485535221302e-03*V(F999) +7.5870076613543576e-04*V(F1000) -2.2362611953812356e-04*V(F1001) +3.2950799039359026e-02*V(F1002) -4.2981097578785474e-02*V(F1003) +5.2972857306039692e-02*V(F1004) -5.0478682557561008e-02*V(F1005) +3.4455848816606828e-02*V(F1006) -1.6592857241760343e-02*V(F1007) +5.6003479990201126e-03*V(F1008) -6.4641266712799810e-04*V(F1009) -5.9909196731154399e-02*V(F1010) +7.4786761627662415e-02*V(F1011) -9.2529872196515969e-02*V(F1012) +8.8131507725177638e-02*V(F1013) -6.0088039907370536e-02*V(F1014) +2.8897860127109553e-02*V(F1015) -9.7993187533361968e-03*V(F1016) +9.8294915895400328e-04*V(F1017) +9.5737312196086069e-02*V(F1018) -1.2228677977880001e-01*V(F1019) +1.5099065090429065e-01*V(F1020) -1.4384922171538514e-01*V(F1021) +9.8135678249558822e-02*V(F1022) -4.7229223441320321e-02*V(F1023) +1.5975989314759464e-02*V(F1024) -1.7296512346498050e-03*V(F1025) -9.0280890067607963e-02*V(F1026) +1.1177472328508668e-01*V(F1027) -1.3839620578558098e-01*V(F1028) +1.3180564319007587e-01*V(F1029) -8.9845256099960261e-02*V(F1030) +4.3197747128936967e-02*V(F1031) -1.4661631623679330e-02*V(F1032) +1.4282424090663187e-03*V(F1033) +7.1470189352728086e-02*V(F1034) -8.8819731629014478e-02*V(F1035) +1.0993653555792365e-01*V(F1036) -1.0470559883571015e-01*V(F1037) +7.1379720555618087e-02*V(F1038) -3.4323527559112277e-02*V(F1039) +1.1644857788503157e-02*V(F1040) -1.1497873353861702e-03*V(F1041) -4.3284517882210119e-02*V(F1042) +5.4131016361374892e-02*V(F1043) -6.6962728733247892e-02*V(F1044) +6.3780945108808398e-02*V(F1045) -4.3487915252993788e-02*V(F1046) +2.0915608776063327e-02*V(F1047) -7.0911342288236326e-03*V(F1048) +7.1576111783098334e-04*V(F1049) +2.1191526906350958e-02*V(F1050) -2.7525547024739486e-02*V(F1051) +3.3936799878115570e-02*V(F1052) -3.2337470432027747e-02*V(F1053) +2.2070584474775484e-02*V(F1054) -1.0627158570495843e-02*V(F1055) +3.5884247338697946e-03*V(F1056) -4.0904153191567483e-04*V(F1057) +1.1208679121264397e-03*V(F1058) -3.2456072345339727e-03*V(F1059) +3.8102662271611389e-03*V(F1060) -3.6529986323562851e-03*V(F1061) +2.5300864571969868e-03*V(F1062) -1.2389368147865067e-03*V(F1063) +3.9381986815752623e-04*V(F1064) -1.2410789960871536e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1018)));
	I(F1019)<+( +1.6103644557968102e-11*V(reduced_0) -6.6193747003994485e-10*V(reduced_1) +2.5853770183839062e-03*V(F929) +5.0227013263814497e-03*V(F937) -6.7146425909124126e-03*V(F945) +1.2727019301078137e-02*V(F953) -9.4522264332519128e-03*V(F961) +7.7232348162428622e-03*V(F969) -4.9214589520495773e-03*V(F977) +3.1462246137365043e-03*V(F985) +1.4544252637960782e-03*V(F993) -6.2088272101787530e-03*V(F994) +1.1820062175189435e-02*V(F995) -1.7432358276761064e-02*V(F996) +1.6974233698162908e-02*V(F997) -1.2475508738292744e-02*V(F998) +6.6757573014176287e-03*V(F999) -2.3726485535193781e-03*V(F1000) +8.3875958064123096e-04*V(F1001) -4.2981097578763131e-02*V(F1002) +8.8553194943512797e-02*V(F1003) -1.0746573424468475e-01*V(F1004) +1.0541187033728781e-01*V(F1005) -7.7320698764630116e-02*V(F1006) +4.1720684862789285e-02*V(F1007) -1.6592857241767348e-02*V(F1008) +1.9583236159311994e-03*V(F1009) +7.4786761627662179e-02*V(F1010) -1.5513993604391527e-01*V(F1011) +1.8491178919524312e-01*V(F1012) -1.8151383819982553e-01*V(F1013) +1.3311535383504233e-01*V(F1014) -7.1887074895204267e-02*V(F1015) +2.8897860127128042e-02*V(F1016) -2.8022831515849959e-03*V(F1017) -1.2228677977880001e-01*V(F1018) +2.5276216722089029e-01*V(F1019) -3.0414985221004764e-01*V(F1020) +2.9844203205522507e-01*V(F1021) -2.1888953370724032e-01*V(F1022) +1.1815524403266661e-01*V(F1023) -4.7229223441344892e-02*V(F1024) +5.1044648534086159e-03*V(F1025) +1.1177472328508228e-01*V(F1026) -2.3217372065322733e-01*V(F1027) +2.7576669890639904e-01*V(F1028) -2.7073882681162154e-01*V(F1029) +1.9854173244323461e-01*V(F1030) -1.0723735137071243e-01*V(F1031) +4.3197747128964091e-02*V(F1032) -4.0138837259939232e-03*V(F1033) -8.8819731629011037e-02*V(F1034) +1.8438169823940279e-01*V(F1035) -2.1935068462472224e-01*V(F1036) +2.1533695955932722e-01*V(F1037) -1.5791656877208529e-01*V(F1038) +8.5288240340581162e-02*V(F1039) -3.4323527559133274e-02*V(F1040) +3.2529810431523804e-03*V(F1041) +5.4131016361368169e-02*V(F1042) -1.1225896008198204e-01*V(F1043) +1.3390301071499044e-01*V(F1044) -1.3143823067771573e-01*V(F1045) +9.6392630130350876e-02*V(F1046) -5.2053624315126980e-02*V(F1047) +2.0915608776074873e-02*V(F1048) -2.0466479855131506e-03*V(F1049) -2.7525547024722135e-02*V(F1050) +5.6747168304460777e-02*V(F1051) -6.8749982130747719e-02*V(F1052) +6.7440773911314936e-02*V(F1053) -4.9467570475293765e-02*V(F1054) +2.6693810536808679e-02*V(F1055) -1.0627158570497995e-02*V(F1056) +1.2330997736601859e-03*V(F1057) -3.2456072345457220e-03*V(F1058) +6.1250343142711583e-03*V(F1059) -9.2182374807133066e-03*V(F1060) +8.9698215300610465e-03*V(F1061) -6.5937546596385324e-03*V(F1062) +3.5256136444814998e-03*V(F1063) -1.2389368147862232e-03*V(F1064) +4.6922186475991263e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1019)));
	I(F1020)<+( -1.8213777293359852e-10*V(reduced_0) +7.4867410405380055e-09*V(reduced_1) -3.2489796990096231e-03*V(F929) -6.3950148295481464e-03*V(F937) +8.5958069070396527e-03*V(F945) -1.6240280630816520e-02*V(F953) +1.2117812337666652e-02*V(F961) -9.8944895903643418e-03*V(F969) +6.2984103269609782e-03*V(F977) -4.0074615866450844e-03*V(F985) -1.8270759280676295e-03*V(F993) +7.3237891210730949e-03*V(F994) -1.7432358276783844e-02*V(F995) +2.4457185036220117e-02*V(F996) -2.7404915773056680e-02*V(F997) +2.1285413102378577e-02*V(F998) -1.2475508738279113e-02*V(F999) +4.8531839038106917e-03*V(F1000) -1.9367677927591941e-03*V(F1001) +5.2972857306015829e-02*V(F1002) -1.0746573424466828e-01*V(F1003) +1.6252155409843022e-01*V(F1004) -1.6502196175080963e-01*V(F1005) +1.2952895629294489e-01*V(F1006) -7.7320698764624135e-02*V(F1007) +3.4455848816622864e-02*V(F1008) -4.1204627857632688e-03*V(F1009) -9.2529872196516760e-02*V(F1010) +1.8491178919524090e-01*V(F1011) -2.8171907173057731e-01*V(F1012) +2.8325376264370367e-01*V(F1013) -2.2257662459056207e-01*V(F1014) +1.3311535383504783e-01*V(F1015) -6.0088039907417977e-02*V(F1016) +5.7090100369794573e-03*V(F1017) +1.5099065090429065e-01*V(F1018) -3.0414985221004764e-01*V(F1019) +4.6157099101547222e-01*V(F1020) -4.6651094475055949e-01*V(F1021) +3.6636285727167683e-01*V(F1022) -2.1888953370723579e-01*V(F1023) +9.8135678249619093e-02*V(F1024) -1.0595654792586288e-02*V(F1025) -1.3839620578557493e-01*V(F1026) +2.7576669890639866e-01*V(F1027) -4.2074397849745770e-01*V(F1028) +4.2222642351473777e-01*V(F1029) -3.3185090504595960e-01*V(F1030) +1.9854173244324611e-01*V(F1031) -8.9845256100030857e-02*V(F1032) +8.1117875990490036e-03*V(F1033) +1.0993653555791889e-01*V(F1034) -2.1935068462472201e-01*V(F1035) +3.3444830901943406e-01*V(F1036) -3.3592141750290549e-01*V(F1037) +2.6399294698965831e-01*V(F1038) -1.5791656877209276e-01*V(F1039) +7.1379720555672432e-02*V(F1040) -6.5989469324708823e-03*V(F1041) -6.6962728733239066e-02*V(F1042) +1.3390301071498881e-01*V(F1043) -2.0394195612289179e-01*V(F1044) +2.0513812047669255e-01*V(F1045) -1.6118697220233028e-01*V(F1046) +9.6392630130353471e-02*V(F1047) -4.3487915253023347e-02*V(F1048) +4.1764757556275135e-03*V(F1049) +3.3936799878093442e-02*V(F1050) -6.8749982130742376e-02*V(F1051) +1.0404342861367871e-01*V(F1052) -1.0554685481274549e-01*V(F1053) +8.2854306795439633e-02*V(F1054) -4.9467570475289158e-02*V(F1055) +2.2070584474779928e-02*V(F1056) -2.5880304771577090e-03*V(F1057) +3.8102662271763212e-03*V(F1058) -9.2182374807164846e-03*V(F1059) +1.2839021189557875e-02*V(F1060) -1.4523087773087638e-02*V(F1061) +1.1269245558918894e-02*V(F1062) -6.5937546596312848e-03*V(F1063) +2.5300864571943609e-03*V(F1064) -1.0866836010416001e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1020)));
	I(F1021)<+( +7.8782916265175352e-11*V(reduced_0) -3.2383578814856272e-09*V(reduced_1) +3.0010957473410116e-03*V(F929) +6.0805061096148565e-03*V(F937) -8.2689763448231327e-03*V(F945) +1.5515626935260807e-02*V(F953) -1.1692837606447655e-02*V(F961) +9.5336924956027722e-03*V(F969) -6.0551685164723420e-03*V(F977) +3.8137066223965280e-03*V(F985) +1.6862909583028381e-03*V(F993) -7.0172455516182520e-03*V(F994) +1.6974233698179974e-02*V(F995) -2.7404915773073513e-02*V(F996) +3.0874272979774339e-02*V(F997) -2.7404915773031259e-02*V(F998) +1.6974233698130819e-02*V(F999) -7.0172455515663049e-03*V(F1000) +3.0010957473285880e-03*V(F1001) -5.0478682557539775e-02*V(F1002) +1.0541187033727582e-01*V(F1003) -1.6502196175079725e-01*V(F1004) +1.9973097337641013e-01*V(F1005) -1.6502196175079459e-01*V(F1006) +1.0541187033727230e-01*V(F1007) -5.0478682557585454e-02*V(F1008) +6.0805061095994426e-03*V(F1009) +8.8131507725178512e-02*V(F1010) -1.8151383819982436e-01*V(F1011) +2.8325376264370183e-01*V(F1012) -3.4532871104224416e-01*V(F1013) +2.8325376264370450e-01*V(F1014) -1.8151383819983483e-01*V(F1015) +8.8131507725254063e-02*V(F1016) -8.2689763447621883e-03*V(F1017) -1.4384922171538514e-01*V(F1018) +2.9844203205522507e-01*V(F1019) -4.6651094475055949e-01*V(F1020) +5.6656077357071744e-01*V(F1021) -4.6651094475053767e-01*V(F1022) +2.9844203205520958e-01*V(F1023) -1.4384922171548031e-01*V(F1024) +1.5515626935172767e-02*V(F1025) +1.3180564319007013e-01*V(F1026) -2.7073882681162054e-01*V(F1027) +4.2222642351473794e-01*V(F1028) -5.1548678176011897e-01*V(F1029) +4.2222642351474576e-01*V(F1030) -2.7073882681164346e-01*V(F1031) +1.3180564319019045e-01*V(F1032) -1.1692837606358124e-02*V(F1033) -1.0470559883570565e-01*V(F1034) +2.1533695955932658e-01*V(F1035) -3.3592141750290588e-01*V(F1036) +4.0985282600093559e-01*V(F1037) -3.3592141750290894e-01*V(F1038) +2.1533695955934121e-01*V(F1039) -1.0470559883579808e-01*V(F1040) +9.5336924955328785e-03*V(F1041) +6.3780945108800183e-02*V(F1042) -1.3143823067771376e-01*V(F1043) +2.0513812047669205e-01*V(F1044) -2.5001730085841478e-01*V(F1045) +2.0513812047669192e-01*V(F1046) -1.3143823067771987e-01*V(F1047) +6.3780945108856055e-02*V(F1048) -6.0551685164344660e-03*V(F1049) -3.2337470432007201e-02*V(F1050) +6.7440773911309232e-02*V(F1051) -1.0554685481274312e-01*V(F1052) +1.2783330793692488e-01*V(F1053) -1.0554685481273643e-01*V(F1054) +6.7440773911304139e-02*V(F1055) -3.2337470432034304e-02*V(F1056) +3.8137066223914158e-03*V(F1057) -3.6529986323704197e-03*V(F1058) +8.9698215300646911e-03*V(F1059) -1.4523087773088847e-02*V(F1060) +1.6251171047212121e-02*V(F1061) -1.4523087773073089e-02*V(F1062) +8.9698215300434980e-03*V(F1063) -3.6529986323505796e-03*V(F1064) +1.6862909582980837e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1021)));
	I(F1022)<+( -1.8213777293386965e-10*V(reduced_0) +7.4867410405491708e-09*V(reduced_1) -1.9367677927668370e-03*V(F929) -4.1204627857730483e-03*V(F937) +5.7090100370182171e-03*V(F945) -1.0595654792642155e-02*V(F953) +8.1117875991060084e-03*V(F961) -6.5989469325153736e-03*V(F969) +4.1764757556516244e-03*V(F977) -2.5880304771609738e-03*V(F985) -1.0866836010444932e-03*V(F993) +4.8531839038419037e-03*V(F994) -1.2475508738304138e-02*V(F995) +2.1285413102389204e-02*V(F996) -2.7404915773046681e-02*V(F997) +2.4457185036174840e-02*V(F998) -1.7432358276719125e-02*V(F999) +7.3237891210134786e-03*V(F1000) -3.2489796989956443e-03*V(F1001) +3.4455848816593374e-02*V(F1002) -7.7320698764622151e-02*V(F1003) +1.2952895629293706e-01*V(F1004) -1.6502196175078288e-01*V(F1005) +1.6252155409840519e-01*V(F1006) -1.0746573424466443e-01*V(F1007) +5.2972857306066219e-02*V(F1008) -6.3950148295310750e-03*V(F1009) -6.0088039907371119e-02*V(F1010) +1.3311535383504156e-01*V(F1011) -2.2257662459056077e-01*V(F1012) +2.8325376264370211e-01*V(F1013) -2.8171907173057903e-01*V(F1014) +1.8491178919525525e-01*V(F1015) -9.2529872196601637e-02*V(F1016) +8.5958069069727479e-03*V(F1017) +9.8135678249558822e-02*V(F1018) -2.1888953370724032e-01*V(F1019) +3.6636285727167683e-01*V(F1020) -4.6651094475053767e-01*V(F1021) +4.6157099101543569e-01*V(F1022) -3.0414985221002805e-01*V(F1023) +1.5099065090439637e-01*V(F1024) -1.6240280630719590e-02*V(F1025) -8.9845256099956569e-02*V(F1026) +1.9854173244323392e-01*V(F1027) -3.3185090504595954e-01*V(F1028) +4.2222642351474649e-01*V(F1029) -4.2074397849747347e-01*V(F1030) +2.7576669890642880e-01*V(F1031) -1.3839620578571027e-01*V(F1032) +1.2117812337568406e-02*V(F1033) +7.1379720555615214e-02*V(F1034) -1.5791656877208476e-01*V(F1035) +2.6399294698965836e-01*V(F1036) -3.3592141750290960e-01*V(F1037) +3.3444830901944189e-01*V(F1038) -2.1935068462474117e-01*V(F1039) +1.0993653555802264e-01*V(F1040) -9.8944895902876046e-03*V(F1041) -4.3487915252988549e-02*V(F1042) +9.6392630130349502e-02*V(F1043) -1.6118697220232980e-01*V(F1044) +2.0513812047669194e-01*V(F1045) -2.0394195612289179e-01*V(F1046) +1.3390301071499652e-01*V(F1047) -6.6962728733301558e-02*V(F1048) +6.2984103269193509e-03*V(F1049) +2.2070584474762407e-02*V(F1050) -4.9467570475289845e-02*V(F1051) +8.2854306795437718e-02*V(F1052) -1.0554685481273528e-01*V(F1053) +1.0404342861366439e-01*V(F1054) -6.8749982130734702e-02*V(F1055) +3.3936799878122904e-02*V(F1056) -4.0074615866393147e-03*V(F1057) +2.5300864572059870e-03*V(F1058) -6.5937546596410686e-03*V(F1059) +1.1269245558919947e-02*V(F1060) -1.4523087773073417e-02*V(F1061) +1.2839021189531855e-02*V(F1062) -9.2182374806895895e-03*V(F1063) +3.8102662271535465e-03*V(F1064) -1.8270759280622755e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1022)));
	I(F1023)<+( +1.6103644558304712e-11*V(reduced_0) -6.6193747005378462e-10*V(reduced_1) +8.3875958064427302e-04*V(F929) +1.9583236159349217e-03*V(F937) -2.8022831516006539e-03*V(F945) +5.1044648534309955e-03*V(F953) -4.0138837260169898e-03*V(F961) +3.2529810431703595e-03*V(F969) -2.0466479855228499e-03*V(F977) +1.2330997736613451e-03*V(F985) +4.6922186476102009e-04*V(F993) -2.3726485535312779e-03*V(F994) +6.6757573014244930e-03*V(F995) -1.2475508738288650e-02*V(F996) +1.6974233698144357e-02*V(F997) -1.7432358276737236e-02*V(F998) +1.1820062175149929e-02*V(F999) -6.2088272101262663e-03*V(F1000) +2.5853770183723542e-03*V(F1001) -1.6592857241754418e-02*V(F1002) +4.1720684862784338e-02*V(F1003) -7.7320698764616946e-02*V(F1004) +1.0541187033726193e-01*V(F1005) -1.0746573424465056e-01*V(F1006) +8.8553194943499919e-02*V(F1007) -4.2981097578805798e-02*V(F1008) +5.0227013263689215e-03*V(F1009) +2.8897860127109719e-02*V(F1010) -7.1887074895203587e-02*V(F1011) +1.3311535383504638e-01*V(F1012) -1.8151383819983258e-01*V(F1013) +1.8491178919525231e-01*V(F1014) -1.5513993604393347e-01*V(F1015) +7.4786761627731194e-02*V(F1016) -6.7146425908611333e-03*V(F1017) -4.7229223441320321e-02*V(F1018) +1.1815524403266661e-01*V(F1019) -2.1888953370723579e-01*V(F1020) +2.9844203205520958e-01*V(F1021) -3.0414985221002805e-01*V(F1022) +2.5276216722088479e-01*V(F1023) -1.2228677977888408e-01*V(F1024) +1.2727019301003799e-02*V(F1025) +4.3197747128935489e-02*V(F1026) -1.0723735137071225e-01*V(F1027) +1.9854173244324652e-01*V(F1028) -2.7073882681164446e-01*V(F1029) +2.7576669890643007e-01*V(F1030) -2.3217372065326630e-01*V(F1031) +1.1177472328519109e-01*V(F1032) -9.4522264331766432e-03*V(F1033) -3.4323527559111125e-02*V(F1034) +8.5288240340581092e-02*V(F1035) -1.5791656877209315e-01*V(F1036) +2.1533695955934207e-01*V(F1037) -2.1935068462474230e-01*V(F1038) +1.8438169823942946e-01*V(F1039) -8.8819731629094442e-02*V(F1040) +7.7232348161840794e-03*V(F1041) +2.0915608776061169e-02*V(F1042) -5.2053624315126439e-02*V(F1043) +9.6392630130353443e-02*V(F1044) -1.3143823067772017e-01*V(F1045) +1.3390301071499700e-01*V(F1046) -1.1225896008199390e-01*V(F1047) +5.4131016361418198e-02*V(F1048) -4.9214589520177919e-03*V(F1049) -1.0627158570490423e-02*V(F1050) +2.6693810536807000e-02*V(F1051) -4.9467570475288339e-02*V(F1052) +6.7440773911303722e-02*V(F1053) -6.8749982130734244e-02*V(F1054) +5.6747168304453963e-02*V(F1055) -2.7525547024745318e-02*V(F1056) +3.1462246137324459e-03*V(F1057) -1.2389368147902200e-03*V(F1058) +3.5256136444825111e-03*V(F1059) -6.5937546596315701e-03*V(F1060) +8.9698215300433332e-03*V(F1061) -9.2182374806893171e-03*V(F1062) +6.1250343142484186e-03*V(F1063) -3.2456072345270291e-03*V(F1064) +1.4544252637917286e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1023)));
	I(F1024)<+( -1.0217484823131212e-10*V(reduced_0) +4.1998791203128897e-09*V(reduced_1) -2.2362611953892923e-04*V(F929) -6.4641266712905975e-04*V(F937) +9.8294915895843506e-04*V(F945) -1.7296512346561476e-03*V(F953) +1.4282424090729061e-03*V(F961) -1.1497873353913050e-03*V(F969) +7.1576111783377353e-04*V(F977) -4.0904153191607598e-04*V(F985) -1.2410789960896272e-04*V(F993) +7.5870076613898034e-04*V(F994) -2.3726485535264931e-03*V(F995) +4.8531839038262409e-03*V(F996) -7.0172455515906109e-03*V(F997) +7.3237891210406166e-03*V(F998) -6.2088272101510650e-03*V(F999) +2.3946602765297638e-03*V(F1000) -2.0766710151095646e-03*V(F1001) +5.6003479990176363e-03*V(F1002) -1.6592857241761870e-02*V(F1003) +3.4455848816610735e-02*V(F1004) -5.0478682557566434e-02*V(F1005) +5.2972857306044972e-02*V(F1006) -4.2981097578786438e-02*V(F1007) +3.2950799039395080e-02*V(F1008) -4.5351222575577919e-03*V(F1009) -9.7993187533359869e-03*V(F1010) +2.8897860127126845e-02*V(F1011) -6.0088039907415139e-02*V(F1012) +8.8131507725249539e-02*V(F1013) -9.2529872196596558e-02*V(F1014) +7.4786761627726628e-02*V(F1015) -5.9909196731242877e-02*V(F1016) +6.3434130089222674e-03*V(F1017) +1.5975989314759464e-02*V(F1018) -4.7229223441344892e-02*V(F1019) +9.8135678249619093e-02*V(F1020) -1.4384922171548031e-01*V(F1021) +1.5099065090439637e-01*V(F1022) -1.2228677977888408e-01*V(F1023) +9.5737312196208471e-02*V(F1024) -1.1708170078783034e-02*V(F1025) -1.4661631623679105e-02*V(F1026) +4.3197747128964611e-02*V(F1027) -8.9845256100032342e-02*V(F1028) +1.3180564319019281e-01*V(F1029) -1.3839620578571291e-01*V(F1030) +1.1177472328519347e-01*V(F1031) -9.0280890067747699e-02*V(F1032) +9.0348596504314180e-03*V(F1033) +1.1644857788502990e-02*V(F1034) -3.4323527559133732e-02*V(F1035) +7.1379720555673681e-02*V(F1036) -1.0470559883580016e-01*V(F1037) +1.0993653555802498e-01*V(F1038) -8.8819731629096482e-02*V(F1039) +7.1470189352836430e-02*V(F1040) -7.3415772101079954e-03*V(F1041) -7.0911342288231946e-03*V(F1042) +2.0915608776075099e-02*V(F1043) -4.3487915253024208e-02*V(F1044) +6.3780945108857526e-02*V(F1045) -6.6962728733303195e-02*V(F1046) +5.4131016361419593e-02*V(F1047) -4.3284517882273457e-02*V(F1048) +4.6382995415430051e-03*V(F1049) +3.5884247338685564e-03*V(F1050) -1.0627158570497923e-02*V(F1051) +2.2070584474780563e-02*V(F1052) -3.2337470432035546e-02*V(F1053) +3.3936799878124320e-02*V(F1054) -2.7525547024746366e-02*V(F1055) +2.1191526906375043e-02*V(F1056) -2.8505558381695323e-03*V(F1057) +3.9381986815832236e-04*V(F1058) -1.2389368147860220e-03*V(F1059) +2.5300864571933296e-03*V(F1060) -3.6529986323487760e-03*V(F1061) +3.8102662271515199e-03*V(F1062) -3.2456072345253650e-03*V(F1063) +1.1208679121154481e-03*V(F1064) -1.1642450107429540e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1024)));
	I(F1025)<+( -1.7162181538909802e-11*V(reduced_0) +7.0544844599238417e-10*V(reduced_1) +2.2561315651505816e-02*V(F841) +8.7236017738845706e-02*V(F850) -1.4094674641107408e-01*V(F859) +2.3982648210406232e-01*V(F868) -2.0753218254437372e-01*V(F877) +1.6604798523439501e-01*V(F886) -1.0234656827775701e-01*V(F895) +5.5490041477950273e-02*V(F904) +1.2344997403666035e-02*V(F913) +3.9665046068306146e-05*V(F929) +7.4362250040292105e-05*V(F937) -9.7900755497070524e-05*V(F945) +1.8725986031917379e-04*V(F953) -1.3724863769912934e-04*V(F961) +1.1236208745138039e-04*V(F969) -7.1815408168533805e-05*V(F977) +4.6528067440893228e-05*V(F985) +2.2335460065389839e-05*V(F993) -2.2362611953936627e-04*V(F994) +8.3875958064553329e-04*V(F995) -1.9367677927694458e-03*V(F996) +3.0010957473448302e-03*V(F997) -3.2489796990135015e-03*V(F998) +2.5853770183867459e-03*V(F999) -2.0766710151206291e-03*V(F1000) +6.3746481417972445e-01*V(F1001) -6.4641266712707349e-04*V(F1002) +1.9583236159279069e-03*V(F1003) -4.1204627857554053e-03*V(F1004) +6.0805061095869787e-03*V(F1005) -6.3950148295173629e-03*V(F1006) +5.0227013263578653e-03*V(F1007) -4.5351222575492588e-03*V(F1008) +2.5045109671863197e+00*V(F1009) +9.8294915895384932e-04*V(F1010) -2.8022831515843254e-03*V(F1011) +5.7090100369778310e-03*V(F1012) -8.2689763447596036e-03*V(F1013) +8.5958069069699012e-03*V(F1014) -6.7146425908588296e-03*V(F1015) +6.3434130089204373e-03*V(F1016) -4.0576961981436650e+00*V(F1017) -1.7296512346498050e-03*V(F1018) +5.1044648534086159e-03*V(F1019) -1.0595654792586288e-02*V(F1020) +1.5515626935172767e-02*V(F1021) -1.6240280630719590e-02*V(F1022) +1.2727019301003799e-02*V(F1023) -1.1708170078783034e-02*V(F1024) +6.8939467593816728e+00*V(F1025) +1.4282424090663430e-03*V(F1026) -4.0138837259941799e-03*V(F1027) +8.1117875990496489e-03*V(F1028) -1.1692837606359155e-02*V(F1029) +1.2117812337569554e-02*V(F1030) -9.4522264331775869e-03*V(F1031) +9.0348596504322178e-03*V(F1032) -5.9780811594819836e+00*V(F1033) -1.1497873353861969e-03*V(F1034) +3.2529810431526146e-03*V(F1035) -6.5989469324714686e-03*V(F1036) +9.5336924955338187e-03*V(F1037) -9.8944895902886455e-03*V(F1038) +7.7232348161849328e-03*V(F1039) -7.3415772101087092e-03*V(F1040) +4.7818257074648729e+00*V(F1041) +7.1576111783094702e-04*V(F1042) -2.0466479855132235e-03*V(F1043) +4.1764757556277269e-03*V(F1044) -6.0551685164348173e-03*V(F1045) +6.2984103269197421e-03*V(F1046) -4.9214589520181250e-03*V(F1047) +4.6382995415433408e-03*V(F1048) -2.9460764145495402e+00*V(F1049) -4.0904153191549837e-04*V(F1050) +1.2330997736600077e-03*V(F1051) -2.5880304771573681e-03*V(F1052) +3.8137066223909101e-03*V(F1053) -4.0074615866387822e-03*V(F1054) +3.1462246137320465e-03*V(F1055) -2.8505558381693992e-03*V(F1056) +1.5934850042948538e+00*V(F1057) -1.2410789960880377e-04*V(F1058) +4.6922186475989696e-04*V(F1059) -1.0866836010414997e-03*V(F1060) +1.6862909582979005e-03*V(F1061) -1.8270759280620578e-03*V(F1062) +1.4544252637915293e-03*V(F1063) -1.1642450107426665e-03*V(F1064) +3.4848782995908656e-01*V(F1065) -1.2405482244889241e+00*V(F1066) +1.4868015713489593e+00*V(F1067) -1.8761111110733473e+00*V(F1068) +1.7490041310322657e+00*V(F1069) -1.1468835379285998e+00*V(F1070) +5.1275837740349550e-01*V(F1071) -1.4820116388582161e-01*V(F1072) -4.8041279220673125e+00*V(F1073) +5.7509218783162765e+00*V(F1074) -7.2577119258504919e+00*V(F1075) +6.7679694594679676e+00*V(F1076) -4.4402054810459823e+00*V(F1077) +1.9870900057571643e+00*V(F1078) -5.7565653917932524e-01*V(F1079) +7.7640863123501447e+00*V(F1080) -9.2923028789096289e+00*V(F1081) +1.1727231375262003e+01*V(F1082) -1.0936444836410235e+01*V(F1083) +7.1756042113726624e+00*V(F1084) -3.2117827964209993e+00*V(F1085) +9.3082249718757404e-01*V(F1086) -1.3208964158741782e+01*V(F1087) +1.5810691769464416e+01*V(F1088) -1.9953432333185379e+01*V(F1089) +1.8607424401615660e+01*V(F1090) -1.2208098291357127e+01*V(F1091) +5.4638115935440892e+00*V(F1092) -1.5831459537910029e+00*V(F1093) +1.1432607970028181e+01*V(F1094) -1.3682308359492932e+01*V(F1095) +1.7267664105241121e+01*V(F1096) -1.6103448990818507e+01*V(F1097) +1.0565964300085716e+01*V(F1098) -4.7294675860178206e+00*V(F1099) +1.3707863256519193e+00*V(F1100) -9.1470727936158802e+00*V(F1101) +1.0947247527201879e+01*V(F1102) -1.3815868647807683e+01*V(F1103) +1.2884315936577698e+01*V(F1104) -8.4537216541210469e+00*V(F1105) +3.7839373857040171e+00*V(F1106) -1.0966914735410651e+00*V(F1107) +5.6377179625073204e+00*V(F1108) -6.7474610839957991e+00*V(F1109) +8.5155378013780378e+00*V(F1110) -7.9413029653804337e+00*V(F1111) +5.2104158114971977e+00*V(F1112) -2.3321516330606595e+00*V(F1113) +6.7588006178927051e-01*V(F1114) -3.0559347097869969e+00*V(F1115) +3.6581291933842852e+00*V(F1116) -4.6165991725336859e+00*V(F1117) +4.3050953673486063e+00*V(F1118) -2.8244297483323368e+00*V(F1119) +1.2640135007167037e+00*V(F1120) -3.6619554293862094e-01*V(F1121) -6.7873832728546135e-01*V(F1122) +8.1352507506298888e-01*V(F1123) -1.0265338666582804e+00*V(F1124) +9.5697020400788846e-01*V(F1125) -6.2750135950315467e-01*V(F1126) +2.8053321164622497e-01*V(F1127) -8.1071093002490172e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1025)));
	I(F1026)<+( +4.4195294490265533e-11*V(reduced_0) -1.8166397871767150e-09*V(reduced_1) +1.8767806733404867e-03*V(F929) +4.2791018034168413e-03*V(F937) -6.3608429842502085e-03*V(F945) +9.0348596504948638e-03*V(F953) -1.3481506345100289e-02*V(F961) +9.0348596504837737e-03*V(F969) -6.3608429842383785e-03*V(F977) +4.2791018034029488e-03*V(F985) +1.8767806733496865e-03*V(F993) -2.0394903559987541e-03*V(F994) +5.4788750971170776e-03*V(F995) -6.4525304869333666e-03*V(F996) +6.1836997393289270e-03*V(F997) -4.2787459229560254e-03*V(F998) +2.0929481965761168e-03*V(F999) -6.6793683675185048e-04*V(F1000) +2.0139015164978886e-04*V(F1001) -3.1296162853121735e-02*V(F1002) +4.0772832407860379e-02*V(F1003) -5.0256556780565349e-02*V(F1004) +4.7889656400358277e-02*V(F1005) -3.2687600203211271e-02*V(F1006) +1.5740749201445553e-02*V(F1007) -5.3134299892095543e-03*V(F1008) +6.1109264235126531e-04*V(F1009) +5.9100958204313499e-02*V(F1010) -7.3959715950842692e-02*V(F1011) +9.1486378393776671e-02*V(F1012) -8.7139965789026705e-02*V(F1013) +5.9415895750743193e-02*V(F1014) -2.8576791617591590e-02*V(F1015) +9.6878521454143701e-03*V(F1016) -9.8010346304458723e-04*V(F1017) -9.0280890067607963e-02*V(F1018) +1.1177472328508228e-01*V(F1019) -1.3839620578557493e-01*V(F1020) +1.3180564319007013e-01*V(F1021) -8.9845256099956569e-02*V(F1022) +4.3197747128935489e-02*V(F1023) -1.4661631623679105e-02*V(F1024) +1.4282424090663430e-03*V(F1025) +1.1545323478371725e-01*V(F1026) -1.4634389986841118e-01*V(F1027) +1.8081703101944160e-01*V(F1028) -1.7225064973001389e-01*V(F1029) +1.1748790056168963e-01*V(F1030) -5.6529538467736576e-02*V(F1031) +1.9137650304208598e-02*V(F1032) -2.0213615798177274e-03*V(F1033) -9.0280890067669109e-02*V(F1034) +1.1177472328514665e-01*V(F1035) -1.3839620578565728e-01*V(F1036) +1.3180564319014820e-01*V(F1037) -8.9845256100009083e-02*V(F1038) +4.3197747128960129e-02*V(F1039) -1.4661631623687398e-02*V(F1040) +1.4282424090663001e-03*V(F1041) +5.9100958204391103e-02*V(F1042) -7.3959715950919047e-02*V(F1043) +9.1486378393874801e-02*V(F1044) -8.7139965789119839e-02*V(F1045) +5.9415895750805893e-02*V(F1046) -2.8576791617621146e-02*V(F1047) +9.6878521454244176e-03*V(F1048) -9.8010346304438058e-04*V(F1049) -3.1296162853181861e-02*V(F1050) +4.0772832407918388e-02*V(F1051) -5.0256556780641663e-02*V(F1052) +4.7889656400430997e-02*V(F1053) -3.2687600203260177e-02*V(F1054) +1.5740749201468403e-02*V(F1055) -5.3134299892169026e-03*V(F1056) +6.1109264235080182e-04*V(F1057) -2.0394903559909769e-03*V(F1058) +5.4788750971275215e-03*V(F1059) -6.4525304869420671e-03*V(F1060) +6.1836997393366769e-03*V(F1061) -4.2787459229613857e-03*V(F1062) +2.0929481965789266e-03*V(F1063) -6.6793683675317266e-04*V(F1064) +2.0139015165096614e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1026)));
	I(F1027)<+( -6.9655627185052400e-12*V(reduced_0) +2.8631822732392004e-10*V(reduced_1) -2.3393245184839362e-03*V(F929) -4.7345340117766121e-03*V(F937) +6.7549686939472201e-03*V(F945) -9.4522264332593028e-03*V(F953) +1.4537395381168142e-02*V(F961) -9.4522264332429617e-03*V(F969) +6.7549686939296387e-03*V(F977) -4.7345340117561805e-03*V(F985) -2.3393245184966400e-03*V(F993) +5.4788750971478204e-03*V(F994) -1.0400157501534783e-02*V(F995) +1.5442306066692391e-02*V(F996) -1.5033015799787962e-02*V(F997) +1.1049467580340554e-02*V(F998) -5.9111151681562404e-03*V(F999) +2.0929481965735685e-03*V(F1000) -7.5745524303638863e-04*V(F1001) +4.0772832407839382e-02*V(F1002) -8.4019281229714443e-02*V(F1003) +1.0191350413733059e-01*V(F1004) -9.9967776638366784e-02*V(F1005) +7.3326999193494669e-02*V(F1006) -3.9566668435530160e-02*V(F1007) +1.5740749201452256e-02*V(F1008) -1.8487093869746661e-03*V(F1009) -7.3959715950840138e-02*V(F1010) +1.5336441130034678e-01*V(F1011) -1.8298447695956843e-01*V(F1012) +1.7961415719374144e-01*V(F1013) -1.3172373965273726e-01*V(F1014) +7.1132080298557915e-02*V(F1015) -2.8576791617609312e-02*V(F1016) +2.8055399768295826e-03*V(F1017) +1.1177472328508668e-01*V(F1018) -2.3217372065322733e-01*V(F1019) +2.7576669890639866e-01*V(F1020) -2.7073882681162054e-01*V(F1021) +1.9854173244323392e-01*V(F1022) -1.0723735137071225e-01*V(F1023) +4.3197747128964611e-02*V(F1024) -4.0138837259941799e-03*V(F1025) -1.4634389986841118e-01*V(F1026) +3.0284965925694945e-01*V(F1027) -3.6327287359223359e-01*V(F1028) +3.5650235597878516e-01*V(F1029) -2.6146407243111452e-01*V(F1030) +1.4115762015336708e-01*V(F1031) -5.6529538467767801e-02*V(F1032) +5.9014135911590587e-03*V(F1033) +1.1177472328513784e-01*V(F1034) -2.3217372065335345e-01*V(F1035) +2.7576669890653088e-01*V(F1036) -2.7073882681175176e-01*V(F1037) +1.9854173244333004e-01*V(F1038) -1.0723735137076428e-01*V(F1039) +4.3197747128986698e-02*V(F1040) -4.0138837259927019e-03*V(F1041) -7.3959715950907348e-02*V(F1042) +1.5336441130050454e-01*V(F1043) -1.8298447695973022e-01*V(F1044) +1.7961415719390206e-01*V(F1045) -1.3172373965285489e-01*V(F1046) +7.1132080298621628e-02*V(F1047) -2.8576791617636571e-02*V(F1048) +2.8055399768272004e-03*V(F1049) +4.0772832407890536e-02*V(F1050) -8.4019281229834875e-02*V(F1051) +1.0191350413744951e-01*V(F1052) -9.9967776638486619e-02*V(F1053) +7.3326999193582557e-02*V(F1054) -3.9566668435577379e-02*V(F1055) +1.5740749201471102e-02*V(F1056) -1.8487093869715193e-03*V(F1057) +5.4788750971462305e-03*V(F1058) -1.0400157501539076e-02*V(F1059) +1.5442306066720127e-02*V(F1060) -1.5033015799811773e-02*V(F1061) +1.1049467580357740e-02*V(F1062) -5.9111151681658603e-03*V(F1063) +2.0929481965785558e-03*V(F1064) -7.5745524304118503e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1027)));
	I(F1028)<+( +7.8782916265377921e-11*V(reduced_0) -3.2383578814939490e-09*V(reduced_1) +2.9393978040896658e-03*V(F929) +6.0288064682324435e-03*V(F937) -8.6440003324247637e-03*V(F945) +1.2117812337676000e-02*V(F953) -1.8568314374356184e-02*V(F961) +1.2117812337655604e-02*V(F969) -8.6440003324028541e-03*V(F977) +6.0288064682067783e-03*V(F985) +2.9393978041057840e-03*V(F993) -6.4525304869671139e-03*V(F994) +1.5442306066713197e-02*V(F995) -2.1612346860088276e-02*V(F996) +2.4294049093360196e-02*V(F997) -1.8863101486258964e-02*V(F998) +1.1049467580328124e-02*V(F999) -4.2787459229465677e-03*V(F1000) +1.7508346670059721e-03*V(F1001) -5.0256556780542833e-02*V(F1002) +1.0191350413731520e-01*V(F1003) -1.5415571834821579e-01*V(F1004) +1.5648578162767643e-01*V(F1005) -1.2283238896163400e-01*V(F1006) +7.3326999193489159e-02*V(F1007) -3.2687600203226683e-02*V(F1008) +3.8870419017602562e-03*V(F1009) +9.1486378393774506e-02*V(F1010) -1.8298447695956530e-01*V(F1011) +2.7866400660689322e-01*V(F1012) -2.8034107902992672e-01*V(F1013) +2.2027381382973146e-01*V(F1014) -1.3172373965274159e-01*V(F1015) +5.9415895750788469e-02*V(F1016) -5.7285267686777034e-03*V(F1017) -1.3839620578558098e-01*V(F1018) +2.7576669890639904e-01*V(F1019) -4.2074397849745770e-01*V(F1020) +4.2222642351473794e-01*V(F1021) -3.3185090504595954e-01*V(F1022) +1.9854173244324652e-01*V(F1023) -8.9845256100032342e-02*V(F1024) +8.1117875990496489e-03*V(F1025) +1.8081703101944160e-01*V(F1026) -3.6327287359223359e-01*V(F1027) +5.5200907999950766e-01*V(F1028) -5.5695655317401316e-01*V(F1029) +4.3747659647012754e-01*V(F1030) -2.6146407243111414e-01*V(F1031) +1.1748790056176757e-01*V(F1032) -1.2179955879141622e-02*V(F1033) -1.3839620578564574e-01*V(F1034) +2.7576669890652872e-01*V(F1035) -4.2074397849766976e-01*V(F1036) +4.2222642351493511e-01*V(F1037) -3.3185090504611581e-01*V(F1038) +1.9854173244334108e-01*V(F1039) -8.9845256100078277e-02*V(F1040) +8.1117875990452306e-03*V(F1041) +9.1486378393859744e-02*V(F1042) -1.8298447695972694e-01*V(F1043) +2.7866400660715590e-01*V(F1044) -2.8034107903016825e-01*V(F1045) +2.2027381382992356e-01*V(F1046) -1.3172373965285802e-01*V(F1047) +5.9415895750845299e-02*V(F1048) -5.7285267686709119e-03*V(F1049) -5.0256556780606199e-02*V(F1050) +1.0191350413744087e-01*V(F1051) -1.5415571834841518e-01*V(F1052) +1.5648578162785531e-01*V(F1053) -1.2283238896177710e-01*V(F1054) +7.3326999193575007e-02*V(F1055) -3.2687600203265416e-02*V(F1056) +3.8870419017518602e-03*V(F1057) -6.4525304869662318e-03*V(F1058) +1.5442306066725203e-02*V(F1059) -2.1612346860109322e-02*V(F1060) +2.4294049093400470e-02*V(F1061) -1.8863101486288260e-02*V(F1062) +1.1049467580346249e-02*V(F1063) -4.2787459229574184e-03*V(F1064) +1.7508346670174774e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1028)));
	I(F1029)<+( -3.4077214162075037e-11*V(reduced_0) +1.4007378793822273e-09*V(reduced_1) -2.7143538346644982e-03*V(F929) -5.7337344109199559e-03*V(F937) +8.3083113003034684e-03*V(F945) -1.1692837606456199e-02*V(F953) +1.7776579021554453e-02*V(F961) -1.1692837606437892e-02*V(F969) +8.3083113002838521e-03*V(F977) -5.7337344108967913e-03*V(F985) -2.7143538346792897e-03*V(F993) +6.1836997393591303e-03*V(F994) -1.5033015799803552e-02*V(F995) +2.4294049093375576e-02*V(F996) -2.7307439062165359e-02*V(F997) +2.4294049093337062e-02*V(F998) -1.5033015799758720e-02*V(F999) +6.1836997393115529e-03*V(F1000) -2.7143538346532637e-03*V(F1001) +4.7889656400338231e-02*V(F1002) -9.9967776638355599e-02*V(F1003) +1.5648578162766480e-01*V(F1004) -1.8943653587616455e-01*V(F1005) +1.5648578162766238e-01*V(F1006) -9.9967776638352601e-02*V(F1007) +4.7889656400381772e-02*V(F1008) -5.7337344109051015e-03*V(F1009) -8.7139965789024873e-02*V(F1010) +1.7961415719373930e-01*V(F1011) -2.8034107902992395e-01*V(F1012) +3.4163440168347126e-01*V(F1013) -2.8034107902992561e-01*V(F1014) +1.7961415719374832e-01*V(F1015) -8.7139965789099522e-02*V(F1016) +8.3083113002455130e-03*V(F1017) +1.3180564319007587e-01*V(F1018) -2.7073882681162154e-01*V(F1019) +4.2222642351473777e-01*V(F1020) -5.1548678176011897e-01*V(F1021) +4.2222642351474649e-01*V(F1022) -2.7073882681164446e-01*V(F1023) +1.3180564319019281e-01*V(F1024) -1.1692837606359155e-02*V(F1025) -1.7225064973001389e-01*V(F1026) +3.5650235597878516e-01*V(F1027) -5.5695655317401316e-01*V(F1028) +6.7726471728203752e-01*V(F1029) -5.5695655317399573e-01*V(F1030) +3.5650235597877844e-01*V(F1031) -1.7225064973013787e-01*V(F1032) +1.7776579021445079e-02*V(F1033) +1.3180564319013746e-01*V(F1034) -2.7073882681174916e-01*V(F1035) +4.2222642351493445e-01*V(F1036) -5.1548678176037344e-01*V(F1037) +4.2222642351494294e-01*V(F1038) -2.7073882681177319e-01*V(F1039) +1.3180564319026059e-01*V(F1040) -1.1692837606351560e-02*V(F1041) -8.7139965789105822e-02*V(F1042) +1.7961415719389837e-01*V(F1043) -2.8034107903016697e-01*V(F1044) +3.4163440168378656e-01*V(F1045) -2.8034107903016686e-01*V(F1046) +1.7961415719390683e-01*V(F1047) -8.7139965789183357e-02*V(F1048) +8.3083113002340100e-03*V(F1049) +4.7889656400398085e-02*V(F1050) -9.9967776638477432e-02*V(F1051) +1.5648578162785134e-01*V(F1052) -1.8943653587640358e-01*V(F1053) +1.5648578162784091e-01*V(F1054) -9.9967776638469077e-02*V(F1055) +4.7889656400438442e-02*V(F1056) -5.7337344108912185e-03*V(F1057) +6.1836997393591754e-03*V(F1058) -1.5033015799817593e-02*V(F1059) +2.4294049093402416e-02*V(F1060) -2.7307439062195068e-02*V(F1061) +2.4294049093377360e-02*V(F1062) -1.5033015799783942e-02*V(F1063) +6.1836997393279400e-03*V(F1064) -2.7143538346714518e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1029)));
	I(F1030)<+( +7.8782916265495303e-11*V(reduced_0) -3.2383578814987827e-09*V(reduced_1) +1.7508346670128835e-03*V(F929) +3.8870419017696875e-03*V(F937) -5.7285267687145645e-03*V(F945) +8.1117875991113947e-03*V(F953) -1.2179955879211080e-02*V(F961) +8.1117875991002213e-03*V(F969) -5.7285267687026496e-03*V(F977) +3.8870419017554233e-03*V(F985) +1.7508346670222549e-03*V(F993) -4.2787459229751664e-03*V(F994) +1.1049467580350971e-02*V(F995) -1.8863101486268671e-02*V(F996) +2.4294049093351151e-02*V(F997) -2.1612346860047007e-02*V(F998) +1.5442306066654173e-02*V(F999) -6.4525304869125118e-03*V(F1000) +2.9393978040770257e-03*V(F1001) -3.2687600203198580e-02*V(F1002) +7.3326999193487175e-02*V(F1003) -1.2283238896162677e-01*V(F1004) +1.5648578162765148e-01*V(F1005) -1.5415571834819264e-01*V(F1006) +1.0191350413731198e-01*V(F1007) -5.0256556780590919e-02*V(F1008) +6.0288064682160018e-03*V(F1009) +5.9415895750742069e-02*V(F1010) -1.3172373965273587e-01*V(F1011) +2.2027381382972996e-01*V(F1012) -2.8034107902992289e-01*V(F1013) +2.7866400660689233e-01*V(F1014) -1.8298447695957762e-01*V(F1015) +9.1486378393858286e-02*V(F1016) -8.6440003323611306e-03*V(F1017) -8.9845256099960261e-02*V(F1018) +1.9854173244323461e-01*V(F1019) -3.3185090504595960e-01*V(F1020) +4.2222642351474576e-01*V(F1021) -4.2074397849747347e-01*V(F1022) +2.7576669890643007e-01*V(F1023) -1.3839620578571291e-01*V(F1024) +1.2117812337569554e-02*V(F1025) +1.1748790056168963e-01*V(F1026) -2.6146407243111452e-01*V(F1027) +4.3747659647012754e-01*V(F1028) -5.5695655317399573e-01*V(F1029) +5.5200907999947946e-01*V(F1030) -3.6327287359222538e-01*V(F1031) +1.8081703101957972e-01*V(F1032) -1.8568314374235867e-02*V(F1033) -8.9845256100002199e-02*V(F1034) +1.9854173244332821e-01*V(F1035) -3.3185090504611520e-01*V(F1036) +4.2222642351494299e-01*V(F1037) -4.2074397849768547e-01*V(F1038) +2.7576669890656003e-01*V(F1039) -1.3839620578578407e-01*V(F1040) +1.2117812337560860e-02*V(F1041) +5.9415895750796976e-02*V(F1042) -1.3172373965285233e-01*V(F1043) +2.2027381382992242e-01*V(F1044) -2.8034107903016647e-01*V(F1045) +2.7866400660715523e-01*V(F1046) -1.8298447695973766e-01*V(F1047) +9.1486378393946369e-02*V(F1048) -8.6440003323480646e-03*V(F1049) -3.2687600203239214e-02*V(F1050) +7.3326999193576201e-02*V(F1051) -1.2283238896177402e-01*V(F1052) +1.5648578162783885e-01*V(F1053) -1.5415571834839240e-01*V(F1054) +1.0191350413742836e-01*V(F1055) -5.0256556780649997e-02*V(F1056) +6.0288064682004171e-03*V(F1057) -4.2787459229757111e-03*V(F1058) +1.1049467580361780e-02*V(F1059) -1.8863101486289943e-02*V(F1060) +2.4294049093377897e-02*V(F1061) -2.1612346860068007e-02*V(F1062) +1.5442306066682506e-02*V(F1063) -6.4525304869303734e-03*V(F1064) +2.9393978040969633e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1030)));
	I(F1031)<+( -6.9655627186507939e-12*V(reduced_0) +2.8631822732990449e-10*V(reduced_1) -7.5745524303913892e-04*V(F929) -1.8487093869782600e-03*V(F937) +2.8055399768444475e-03*V(F945) -4.0138837260192076e-03*V(F953) +5.9014135911869712e-03*V(F961) -4.0138837260149289e-03*V(F969) +2.8055399768399480e-03*V(F977) -1.8487093869727043e-03*V(F985) -7.5745524304301776e-04*V(F993) +2.0929481965844760e-03*V(F994) -5.9111151681625106e-03*V(F995) +1.1049467580336833e-02*V(F996) -1.5033015799771092e-02*V(F997) +1.5442306066670726e-02*V(F998) -1.0400157501498742e-02*V(F999) +5.4788750970997677e-03*V(F1000) -2.3393245184734797e-03*V(F1001) +1.5740749201439971e-02*V(F1002) -3.9566668435525545e-02*V(F1003) +7.3326999193482414e-02*V(F1004) -9.9967776638342942e-02*V(F1005) +1.0191350413729909e-01*V(F1006) -8.4019281229702800e-02*V(F1007) +4.0772832407879989e-02*V(F1008) -4.7345340117645350e-03*V(F1009) -2.8576791617591048e-02*V(F1010) +7.1132080298556999e-02*V(F1011) -1.3172373965273990e-01*V(F1012) +1.7961415719374568e-01*V(F1013) -1.8298447695957420e-01*V(F1014) +1.5336441130036255e-01*V(F1015) -7.3959715950908167e-02*V(F1016) +6.7549686938984891e-03*V(F1017) +4.3197747128936967e-02*V(F1018) -1.0723735137071243e-01*V(F1019) +1.9854173244324611e-01*V(F1020) -2.7073882681164346e-01*V(F1021) +2.7576669890642880e-01*V(F1022) -2.3217372065326630e-01*V(F1023) +1.1177472328519347e-01*V(F1024) -9.4522264331775869e-03*V(F1025) -5.6529538467736576e-02*V(F1026) +1.4115762015336708e-01*V(F1027) -2.6146407243111414e-01*V(F1028) +3.5650235597877844e-01*V(F1029) -3.6327287359222538e-01*V(F1030) +3.0284965925695689e-01*V(F1031) -1.4634389986852175e-01*V(F1032) +1.4537395381075865e-02*V(F1033) +4.3197747128957298e-02*V(F1034) -1.0723735137076357e-01*V(F1035) +1.9854173244334100e-01*V(F1036) -2.7073882681177364e-01*V(F1037) +2.7576669890656064e-01*V(F1038) -2.3217372065339245e-01*V(F1039) +1.1177472328524919e-01*V(F1040) -9.4522264331704815e-03*V(F1041) -2.8576791617617472e-02*V(F1042) +7.1132080298620601e-02*V(F1043) -1.3172373965285772e-01*V(F1044) +1.7961415719390689e-01*V(F1045) -1.8298447695973780e-01*V(F1046) +1.5336441130052014e-01*V(F1047) -7.3959715950976779e-02*V(F1048) +6.7549686938878639e-03*V(F1049) +1.5740749201459712e-02*V(F1050) -3.9566668435574645e-02*V(F1051) +7.3326999193573605e-02*V(F1052) -9.9967776638468314e-02*V(F1053) +1.0191350413742745e-01*V(F1054) -8.4019281229823273e-02*V(F1055) +4.0772832407924973e-02*V(F1056) -4.7345340117518871e-03*V(F1057) +2.0929481965848377e-03*V(F1058) -5.9111151681674762e-03*V(F1059) +1.1049467580346712e-02*V(F1060) -1.5033015799783703e-02*V(F1061) +1.5442306066682097e-02*V(F1062) -1.0400157501503037e-02*V(F1063) +5.4788750971167879e-03*V(F1064) -2.3393245184894882e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1031)));
	I(F1032)<+( +4.4195294490450304e-11*V(reduced_0) -1.8166397871843247e-09*V(reduced_1) +2.0139015165051674e-04*V(F929) +6.1109264235229130e-04*V(F937) -9.8010346304880087e-04*V(F945) +1.4282424090734302e-03*V(F953) -2.0213615798256464e-03*V(F961) +1.4282424090726672e-03*V(F969) -9.8010346304805776e-04*V(F977) +6.1109264235125328e-04*V(F985) +2.0139015165137984e-04*V(F993) -6.6793683675508942e-04*V(F994) +2.0929481965800707e-03*V(F995) -4.2787459229607751e-03*V(F996) +6.1836997393337608e-03*V(F997) -6.4525304869373114e-03*V(F998) +5.4788750971224249e-03*V(F999) -2.0394903559817022e-03*V(F1000) +1.8767806733310480e-03*V(F1001) -5.3134299892072280e-03*V(F1002) +1.5740749201447156e-02*V(F1003) -3.2687600203215386e-02*V(F1004) +4.7889656400364085e-02*V(F1005) -5.0256556780571150e-02*V(F1006) +4.0772832407861954e-02*V(F1007) -3.1296162853156353e-02*V(F1008) +4.2791018034066654e-03*V(F1009) +9.6878521454139693e-03*V(F1010) -2.8576791617607965e-02*V(F1011) +5.9415895750785340e-02*V(F1012) -8.7139965789094595e-02*V(F1013) +9.1486378393852777e-02*V(F1014) -7.3959715950903199e-02*V(F1015) +5.9100958204399576e-02*V(F1016) -6.3608429842124609e-03*V(F1017) -1.4661631623679330e-02*V(F1018) +4.3197747128964091e-02*V(F1019) -8.9845256100030857e-02*V(F1020) +1.3180564319019045e-01*V(F1021) -1.3839620578571027e-01*V(F1022) +1.1177472328519109e-01*V(F1023) -9.0280890067747699e-02*V(F1024) +9.0348596504322178e-03*V(F1025) +1.9137650304208598e-02*V(F1026) -5.6529538467767801e-02*V(F1027) +1.1748790056176757e-01*V(F1028) -1.7225064973013787e-01*V(F1029) +1.8081703101957972e-01*V(F1030) -1.4634389986852175e-01*V(F1031) +1.1545323478387270e-01*V(F1032) -1.3481506345027648e-02*V(F1033) -1.4661631623686821e-02*V(F1034) +4.3197747128986975e-02*V(F1035) -8.9845256100079332e-02*V(F1036) +1.3180564319026242e-01*V(F1037) -1.3839620578578615e-01*V(F1038) +1.1177472328525093e-01*V(F1039) -9.0280890067808928e-02*V(F1040) +9.0348596504276277e-03*V(F1041) +9.6878521454236161e-03*V(F1042) -2.8576791617636706e-02*V(F1043) +5.9415895750846166e-02*V(F1044) -8.7139965789184912e-02*V(F1045) +9.1486378393948117e-02*V(F1046) -7.3959715950978208e-02*V(F1047) +5.9100958204477270e-02*V(F1048) -6.3608429842054144e-03*V(F1049) -5.3134299892149042e-03*V(F1050) +1.5740749201470925e-02*V(F1051) -3.2687600203266283e-02*V(F1052) +4.7889656400440211e-02*V(F1053) -5.0256556780651995e-02*V(F1054) +4.0772832407926438e-02*V(F1055) -3.1296162853216604e-02*V(F1056) +4.2791018033977142e-03*V(F1057) -6.6793683675444172e-04*V(F1058) +2.0929481965782449e-03*V(F1059) -4.2787459229557982e-03*V(F1060) +6.1836997393251028e-03*V(F1061) -6.4525304869271858e-03*V(F1062) +5.4788750971141737e-03*V(F1063) -2.0394903559738994e-03*V(F1064) +1.8767806733434888e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1032)));
	I(F1033)<+( +7.4234283714673211e-12*V(reduced_0) -3.0513871425462492e-10*V(reduced_1) -2.0218928184540689e-02*V(F841) -8.2592781392242423e-02*V(F850) +1.4000165800950234e-01*V(F859) -2.0753218254432201e-01*V(F868) +2.8329371990065616e-01*V(F877) -2.0753218254443159e-01*V(F886) +1.4000165800961456e-01*V(F895) -8.2592781392395107e-02*V(F904) -2.0218928184510699e-02*V(F913) -3.5902216976709335e-05*V(F929) -7.0073393906747232e-05*V(F937) +9.8600012798701509e-05*V(F945) -1.3724863769918106e-04*V(F953) +2.1331594642520364e-04*V(F961) -1.3724863769900214e-04*V(F969) +9.8600012798495117e-05*V(F977) -7.0073393906555382e-05*V(F985) -3.5902216976830887e-05*V(F993) +2.0139015165092440e-04*V(F994) -7.5745524304031962e-04*V(F995) +1.7508346670153392e-03*V(F996) -2.7143538346681055e-03*V(F997) +2.9393978040933399e-03*V(F998) -2.3393245184866293e-03*V(F999) +1.8767806733411567e-03*V(F1000) -5.7110275048914350e-01*V(F1001) +6.1109264235040251e-04*V(F1002) -1.8487093869715998e-03*V(F1003) +3.8870419017529353e-03*V(F1004) -5.7337344108934953e-03*V(F1005) +6.0288064682032360e-03*V(F1006) -4.7345340117542420e-03*V(F1007) +4.2791018033987265e-03*V(F1008) -2.3713716671033200e+00*V(F1009) -9.8010346304439012e-04*V(F1010) +2.8055399768288063e-03*V(F1011) -5.7285267686758385e-03*V(F1012) +8.3083113002425466e-03*V(F1013) -8.6440003323578658e-03*V(F1014) +6.7549686938958506e-03*V(F1015) -6.3608429842103896e-03*V(F1016) +4.0298073472374405e+00*V(F1017) +1.4282424090663187e-03*V(F1018) -4.0138837259939232e-03*V(F1019) +8.1117875990490036e-03*V(F1020) -1.1692837606358124e-02*V(F1021) +1.2117812337568406e-02*V(F1022) -9.4522264331766432e-03*V(F1023) +9.0348596504314180e-03*V(F1024) -5.9780811594819836e+00*V(F1025) -2.0213615798177274e-03*V(F1026) +5.9014135911590587e-03*V(F1027) -1.2179955879141622e-02*V(F1028) +1.7776579021445079e-02*V(F1029) -1.8568314374235867e-02*V(F1030) +1.4537395381075865e-02*V(F1031) -1.3481506345027648e-02*V(F1032) +8.1473960796474003e+00*V(F1033) +1.4282424090662489e-03*V(F1034) -4.0138837259927817e-03*V(F1035) +8.1117875990454683e-03*V(F1036) -1.1692837606351954e-02*V(F1037) +1.2117812337561311e-02*V(F1038) -9.4522264331708648e-03*V(F1039) +9.0348596504280284e-03*V(F1040) -5.9780811594832750e+00*V(F1041) -9.8010346304428474e-04*V(F1042) +2.8055399768271809e-03*V(F1043) -5.7285267686709267e-03*V(F1044) +8.3083113002340551e-03*V(F1045) -8.6440003323481375e-03*V(F1046) +6.7549686938879446e-03*V(F1047) -6.3608429842056027e-03*V(F1048) +4.0298073472388669e+00*V(F1049) +6.1109264235051104e-04*V(F1050) -1.8487093869712003e-03*V(F1051) +3.8870419017512331e-03*V(F1052) -5.7337344108902783e-03*V(F1053) +6.0288064681994170e-03*V(F1054) -4.7345340117511316e-03*V(F1055) +4.2791018033974081e-03*V(F1056) -2.3713716671042837e+00*V(F1057) +2.0139015165110803e-04*V(F1058) -7.5745524304116508e-04*V(F1059) +1.7508346670173302e-03*V(F1060) -2.7143538346711816e-03*V(F1061) +2.9393978040966398e-03*V(F1062) -2.3393245184891889e-03*V(F1063) +1.8767806733430458e-03*V(F1064) -5.7110275049066650e-01*V(F1065) +1.1117172852917792e+00*V(F1066) -1.3324279958859593e+00*V(F1067) +1.6813115340680522e+00*V(F1068) -1.5673934158951992e+00*V(F1069) +1.0277850647790980e+00*V(F1070) -4.5950216691486995e-01*V(F1071) +1.3280266943881650e-01*V(F1072) +4.5484537331134947e+00*V(F1073) -5.4448309999335507e+00*V(F1074) +6.8714266222319109e+00*V(F1075) -6.4077585080909190e+00*V(F1076) +4.2038941219046162e+00*V(F1077) -1.8813435065582576e+00*V(F1078) +5.4502753184134967e-01*V(F1079) -7.7118989013754433e+00*V(F1080) +9.2299605507133755e+00*V(F1081) -1.1648536786165826e+01*V(F1082) +1.0863022981114572e+01*V(F1083) -7.1273928865758149e+00*V(F1084) +3.1901705361089268e+00*V(F1085) -9.2453612384164952e-01*V(F1086) +1.1432607970023447e+01*V(F1087) -1.3682308359486360e+01*V(F1088) +1.7267664105232843e+01*V(F1089) -1.6103448990810936e+01*V(F1090) +1.0565964300080948e+01*V(F1091) -4.7294675860158524e+00*V(F1092) +1.3707863256514465e+00*V(F1093) -1.5603755080201090e+01*V(F1094) +1.8676495344756443e+01*V(F1095) -2.3570232480880936e+01*V(F1096) +2.1980440786207982e+01*V(F1097) -1.4421312452092721e+01*V(F1098) +6.4545414538952137e+00*V(F1099) -1.8703438394339067e+00*V(F1100) +1.1432607970031805e+01*V(F1101) -1.3682308359497450e+01*V(F1102) +1.7267664105246840e+01*V(F1103) -1.6103448990823793e+01*V(F1104) +1.0565964300089153e+01*V(F1105) -4.7294675860193243e+00*V(F1106) +1.3707863256523360e+00*V(F1107) -7.7118989013838455e+00*V(F1108) +9.2299605507244724e+00*V(F1109) -1.1648536786179827e+01*V(F1110) +1.0863022981127452e+01*V(F1111) -7.1273928865840386e+00*V(F1112) +3.1901705361124151e+00*V(F1113) -9.2453612384255102e-01*V(F1114) +4.5484537331261325e+00*V(F1115) -5.4448309999507059e+00*V(F1116) +6.8714266222535443e+00*V(F1117) -6.4077585081107422e+00*V(F1118) +4.2038941219171857e+00*V(F1119) -1.8813435065635076e+00*V(F1120) +5.4502753184265684e-01*V(F1121) +1.1117172852871933e+00*V(F1122) -1.3324279958790437e+00*V(F1123) +1.6813115340593410e+00*V(F1124) -1.5673934158873273e+00*V(F1125) +1.0277850647742433e+00*V(F1126) -4.5950216691296475e-01*V(F1127) +1.3280266943841409e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1033)));
	I(F1034)<+( -1.0217484823091561e-10*V(reduced_0) +4.1998791202965571e-09*V(reduced_1) -1.1642450107409422e-03*V(F929) -2.8505558381823380e-03*V(F937) +4.6382995415744158e-03*V(F945) -7.3415772101578219e-03*V(F953) +9.0348596504926243e-03*V(F961) -1.1708170078835100e-02*V(F969) +6.3434130089455804e-03*V(F977) -4.5351222575525469e-03*V(F985) -2.0766710151301155e-03*V(F993) +1.1208679121307576e-03*V(F994) -3.2456072345267550e-03*V(F995) +3.8102662271548614e-03*V(F996) -3.6529986323506490e-03*V(F997) +2.5300864571930976e-03*V(F998) -1.2389368147844892e-03*V(F999) +3.9381986815660770e-04*V(F1000) -1.2410789960796937e-04*V(F1001) +2.1191526906316885e-02*V(F1002) -2.7525547024706516e-02*V(F1003) +3.3936799878072049e-02*V(F1004) -3.2337470431986232e-02*V(F1005) +2.2070584474747572e-02*V(F1006) -1.0627158570482832e-02*V(F1007) +3.5884247338656577e-03*V(F1008) -4.0904153191596387e-04*V(F1009) -4.3284517882176750e-02*V(F1010) +5.4131016361341329e-02*V(F1011) -6.6962728733204441e-02*V(F1012) +6.3780945108767181e-02*V(F1013) -4.3487915252966122e-02*V(F1014) +2.0915608776050316e-02*V(F1015) -7.0911342288193001e-03*V(F1016) +7.1576111783110000e-04*V(F1017) +7.1470189352728086e-02*V(F1018) -8.8819731629011037e-02*V(F1019) +1.0993653555791889e-01*V(F1020) -1.0470559883570565e-01*V(F1021) +7.1379720555615214e-02*V(F1022) -3.4323527559111125e-02*V(F1023) +1.1644857788502990e-02*V(F1024) -1.1497873353861969e-03*V(F1025) -9.0280890067669109e-02*V(F1026) +1.1177472328513784e-01*V(F1027) -1.3839620578564574e-01*V(F1028) +1.3180564319013746e-01*V(F1029) -8.9845256100002199e-02*V(F1030) +4.3197747128957298e-02*V(F1031) -1.4661631623686821e-02*V(F1032) +1.4282424090662489e-03*V(F1033) +9.5737312196191526e-02*V(F1034) -1.2228677977889955e-01*V(F1035) +1.5099065090441752e-01*V(F1036) -1.4384922171550557e-01*V(F1037) +9.8135678249640243e-02*V(F1038) -4.7229223441359103e-02*V(F1039) +1.5975989314773082e-02*V(F1040) -1.7296512346497098e-03*V(F1041) -5.9909196731254832e-02*V(F1042) +7.4786761627762946e-02*V(F1043) -9.2529872196644894e-02*V(F1044) +8.8131507725299915e-02*V(F1045) -6.0088039907452789e-02*V(F1046) +2.8897860127148265e-02*V(F1047) -9.7993187533493564e-03*V(F1048) +9.8294915895378730e-04*V(F1049) +3.2950799039428935e-02*V(F1050) -4.2981097578853648e-02*V(F1051) +5.2972857306129086e-02*V(F1052) -5.0478682557646183e-02*V(F1053) +3.4455848816664102e-02*V(F1054) -1.6592857241787093e-02*V(F1055) +5.6003479990287593e-03*V(F1056) -6.4641266712751053e-04*V(F1057) +2.3946602765395016e-03*V(F1058) -6.2088272101562458e-03*V(F1059) +7.3237891210453133e-03*V(F1060) -7.0172455515933362e-03*V(F1061) +4.8531839038265939e-03*V(F1062) -2.3726485535250953e-03*V(F1063) +7.5870076613684630e-04*V(F1064) -2.2362611953941072e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1034)));
	I(F1035)<+( +1.6103644557972913e-11*V(reduced_0) -6.6193747004014265e-10*V(reduced_1) +1.4544252637880869e-03*V(F929) +3.1462246137489314e-03*V(F937) -4.9214589520590185e-03*V(F945) +7.7232348162487889e-03*V(F953) -9.4522264332552557e-03*V(F961) +1.2727019301066934e-02*V(F969) -6.7146425908884031e-03*V(F977) +5.0227013263581645e-03*V(F985) +2.5853770183979019e-03*V(F993) -3.2456072345461188e-03*V(F994) +6.1250343142671268e-03*V(F995) -9.2182374806943357e-03*V(F996) +8.9698215300445770e-03*V(F997) -6.5937546596266340e-03*V(F998) +3.5256136444748545e-03*V(F999) -1.2389368147828355e-03*V(F1000) +4.6922186475688380e-04*V(F1001) -2.7525547024693300e-02*V(F1002) +5.6747168304392623e-02*V(F1003) -6.8749982130680731e-02*V(F1004) +6.7440773911247281e-02*V(F1005) -4.9467570475244131e-02*V(F1006) +2.6693810536782069e-02*V(F1007) -1.0627158570487513e-02*V(F1008) +1.2330997736620898e-03*V(F1009) +5.4131016361340031e-02*V(F1010) -1.1225896008191424e-01*V(F1011) +1.3390301071492108e-01*V(F1012) -1.3143823067764665e-01*V(F1013) +9.6392630130300333e-02*V(F1014) -5.2053624315099675e-02*V(F1015) +2.0915608776063431e-02*V(F1016) -2.0466479855143220e-03*V(F1017) -8.8819731629014478e-02*V(F1018) +1.8438169823940279e-01*V(F1019) -2.1935068462472201e-01*V(F1020) +2.1533695955932658e-01*V(F1021) -1.5791656877208476e-01*V(F1022) +8.5288240340581092e-02*V(F1023) -3.4323527559133732e-02*V(F1024) +3.2529810431526146e-03*V(F1025) +1.1177472328514665e-01*V(F1026) -2.3217372065335345e-01*V(F1027) +2.7576669890652872e-01*V(F1028) -2.7073882681174916e-01*V(F1029) +1.9854173244332821e-01*V(F1030) -1.0723735137076357e-01*V(F1031) +4.3197747128986975e-02*V(F1032) -4.0138837259927817e-03*V(F1033) -1.2228677977889955e-01*V(F1034) +2.5276216722110795e-01*V(F1035) -3.0414985221027391e-01*V(F1036) +2.9844203205544834e-01*V(F1037) -2.1888953370740380e-01*V(F1038) +1.1815524403275553e-01*V(F1039) -4.7229223441383722e-02*V(F1040) +5.1044648534063581e-03*V(F1041) +7.4786761627747528e-02*V(F1042) -1.5513993604411924e-01*V(F1043) +1.8491178919545348e-01*V(F1044) -1.8151383820003411e-01*V(F1045) +1.3311535383519499e-01*V(F1046) -7.1887074895287034e-02*V(F1047) +2.8897860127163586e-02*V(F1048) -2.8022831515820829e-03*V(F1049) -4.2981097578822583e-02*V(F1050) +8.8553194943653379e-02*V(F1051) -1.0746573424482443e-01*V(F1052) +1.0541187033742837e-01*V(F1053) -7.7320698764733270e-02*V(F1054) +4.1720684862844713e-02*V(F1055) -1.6592857241789615e-02*V(F1056) +1.9583236159277429e-03*V(F1057) -6.2088272101768361e-03*V(F1058) +1.1820062175193626e-02*V(F1059) -1.7432358276790866e-02*V(F1060) +1.6974233698188408e-02*V(F1061) -1.2475508738311139e-02*V(F1062) +6.6757573014279339e-03*V(F1063) -2.3726485535247397e-03*V(F1064) +8.3875958064648132e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1035)));
	I(F1036)<+( -1.8213777293365379e-10*V(reduced_0) +7.4867410405402770e-09*V(reduced_1) -1.8270759280574918e-03*V(F929) -4.0074615866607021e-03*V(F937) +6.2984103269727847e-03*V(F945) -9.8944895903718272e-03*V(F953) +1.2117812337671121e-02*V(F961) -1.6240280630802781e-02*V(F969) +8.5958069070097218e-03*V(F977) -6.3950148295189102e-03*V(F985) -3.2489796990273758e-03*V(F993) +3.8102662271761083e-03*V(F994) -9.2182374807074467e-03*V(F995) +1.2839021189542289e-02*V(F996) -1.4523087773060028e-02*V(F997) +1.1269245558898673e-02*V(F998) -6.5937546596187991e-03*V(F999) +2.5300864571870100e-03*V(F1000) -1.0866836010343453e-03*V(F1001) +3.3936799878057894e-02*V(F1002) -6.8749982130671031e-02*V(F1003) +1.0404342861356589e-01*V(F1004) -1.0554685481264464e-01*V(F1005) +8.2854306795358795e-02*V(F1006) -4.9467570475240828e-02*V(F1007) +2.2070584474758476e-02*V(F1008) -2.5880304771627579e-03*V(F1009) -6.6962728733203650e-02*V(F1010) +1.3390301071491906e-01*V(F1011) -2.0394195612277882e-01*V(F1012) +2.0513812047658900e-01*V(F1013) -1.6118697220224781e-01*V(F1014) +9.6392630130303678e-02*V(F1015) -4.3487915252999602e-02*V(F1016) +4.1764757556307973e-03*V(F1017) +1.0993653555792365e-01*V(F1018) -2.1935068462472224e-01*V(F1019) +3.3444830901943406e-01*V(F1020) -3.3592141750290588e-01*V(F1021) +2.6399294698965836e-01*V(F1022) -1.5791656877209315e-01*V(F1023) +7.1379720555673681e-02*V(F1024) -6.5989469324714686e-03*V(F1025) -1.3839620578565728e-01*V(F1026) +2.7576669890653088e-01*V(F1027) -4.2074397849766976e-01*V(F1028) +4.2222642351493445e-01*V(F1029) -3.3185090504611520e-01*V(F1030) +1.9854173244334100e-01*V(F1031) -8.9845256100079332e-02*V(F1032) +8.1117875990454683e-03*V(F1033) +1.5099065090441752e-01*V(F1034) -3.0414985221027391e-01*V(F1035) +4.6157099101583732e-01*V(F1036) -4.6651094475089872e-01*V(F1037) +3.6636285727194590e-01*V(F1038) -2.1888953370739930e-01*V(F1039) +9.8135678249700639e-02*V(F1040) -1.0595654792579444e-02*V(F1041) -9.2529872196625049e-02*V(F1042) +1.8491178919544918e-01*V(F1043) -2.8171907173091726e-01*V(F1044) +2.8325376264401708e-01*V(F1045) -2.2257662459081101e-01*V(F1046) +1.3311535383519868e-01*V(F1047) -6.0088039907492126e-02*V(F1048) +5.7090100369710682e-03*V(F1049) +5.2972857306089520e-02*V(F1050) -1.0746573424481480e-01*V(F1051) +1.6252155409866348e-01*V(F1052) -1.6502196175101974e-01*V(F1053) +1.2952895629311276e-01*V(F1054) -7.7320698764724943e-02*V(F1055) +3.4455848816668695e-02*V(F1056) -4.1204627857539828e-03*V(F1057) +7.3237891210719093e-03*V(F1058) -1.7432358276796463e-02*V(F1059) +2.4457185036242300e-02*V(F1060) -2.7404915773099902e-02*V(F1061) +2.1285413102409976e-02*V(F1062) -1.2475508738298547e-02*V(F1063) +4.8531839038223681e-03*V(F1064) -1.9367677927717897e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1036)));
	I(F1037)<+( +7.8782916265199405e-11*V(reduced_0) -3.2383578814866152e-09*V(reduced_1) +1.6862909582935285e-03*V(F929) +3.8137066224106443e-03*V(F937) -6.0551685164829602e-03*V(F945) +9.5336924956096279e-03*V(F953) -1.1692837606452070e-02*V(F961) +1.5515626935248817e-02*V(F969) -8.2689763447963190e-03*V(F977) +6.0805061095884818e-03*V(F985) +3.0010957473573041e-03*V(F993) -3.6529986323696629e-03*V(F994) +8.9698215300544077e-03*V(F995) -1.4523087773069718e-02*V(F996) +1.6251171047190580e-02*V(F997) -1.4523087773045441e-02*V(F998) +8.9698215300261421e-03*V(F999) -3.6529986323394952e-03*V(F1000) +1.6862909582866198e-03*V(F1001) -3.2337470431973672e-02*V(F1002) +6.7440773911240218e-02*V(F1003) -1.0554685481263729e-01*V(F1004) +1.2783330793678957e-01*V(F1005) -1.0554685481263594e-01*V(F1006) +6.7440773911238566e-02*V(F1007) -3.2337470432002975e-02*V(F1008) +3.8137066223997481e-03*V(F1009) +6.3780945108766585e-02*V(F1010) -1.3143823067764537e-01*V(F1011) +2.0513812047658728e-01*V(F1012) -2.5001730085827933e-01*V(F1013) +2.0513812047658858e-01*V(F1014) -1.3143823067765220e-01*V(F1015) +6.3780945108821110e-02*V(F1016) -6.0551685164399833e-03*V(F1017) -1.0470559883571015e-01*V(F1018) +2.1533695955932722e-01*V(F1019) -3.3592141750290549e-01*V(F1020) +4.0985282600093559e-01*V(F1021) -3.3592141750290960e-01*V(F1022) +2.1533695955934207e-01*V(F1023) -1.0470559883580016e-01*V(F1024) +9.5336924955338187e-03*V(F1025) +1.3180564319014820e-01*V(F1026) -2.7073882681175176e-01*V(F1027) +4.2222642351493511e-01*V(F1028) -5.1548678176037344e-01*V(F1029) +4.2222642351494299e-01*V(F1030) -2.7073882681177364e-01*V(F1031) +1.3180564319026242e-01*V(F1032) -1.1692837606351954e-02*V(F1033) -1.4384922171550557e-01*V(F1034) +2.9844203205544834e-01*V(F1035) -4.6651094475089872e-01*V(F1036) +5.6656077357115675e-01*V(F1037) -4.6651094475087701e-01*V(F1038) +2.9844203205543302e-01*V(F1039) -1.4384922171560088e-01*V(F1040) +1.5515626935160903e-02*V(F1041) +8.8131507725281458e-02*V(F1042) -1.8151383820002923e-01*V(F1043) +2.8325376264401542e-01*V(F1044) -3.4532871104265217e-01*V(F1045) +2.8325376264401703e-01*V(F1046) -1.8151383820004049e-01*V(F1047) +8.8131507725363475e-02*V(F1048) -8.2689763447479463e-03*V(F1049) -5.0478682557609449e-02*V(F1050) +1.0541187033741807e-01*V(F1051) -1.6502196175101530e-01*V(F1052) +1.9973097337668994e-01*V(F1053) -1.6502196175100406e-01*V(F1054) +1.0541187033740908e-01*V(F1055) -5.0478682557652518e-02*V(F1056) +6.0805061095840600e-03*V(F1057) -7.0172455516180950e-03*V(F1058) +1.6974233698194823e-02*V(F1059) -2.7404915773102053e-02*V(F1060) +3.0874272979805790e-02*V(F1061) -2.7404915773074544e-02*V(F1062) +1.6974233698157898e-02*V(F1063) -7.0172455515839591e-03*V(F1064) +3.0010957473485048e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1037)));
	I(F1038)<+( -1.8213777293392487e-10*V(reduced_0) +7.4867410405514406e-09*V(reduced_1) -1.0866836010385906e-03*V(F929) -2.5880304771696777e-03*V(F937) +4.1764757556581262e-03*V(F945) -6.5989469325196913e-03*V(F953) +8.1117875991091621e-03*V(F961) -1.0595654792635235e-02*V(F969) +5.7090100370018951e-03*V(F977) -4.1204627857568234e-03*V(F985) -1.9367677927771582e-03*V(F993) +2.5300864572051470e-03*V(F994) -6.5937546596331956e-03*V(F995) +1.1269245558904788e-02*V(F996) -1.4523087773054326e-02*V(F997) +1.2839021189516296e-02*V(F998) -9.2182374806702334e-03*V(F999) +3.8102662271414941e-03*V(F1000) -1.8270759280497135e-03*V(F1001) +2.2070584474739623e-02*V(F1002) -4.9467570475239406e-02*V(F1003) +8.2854306795354188e-02*V(F1004) -1.0554685481262899e-01*V(F1005) +1.0404342861355136e-01*V(F1006) -6.8749982130669365e-02*V(F1007) +3.3936799878090312e-02*V(F1008) -4.0074615866486606e-03*V(F1009) -4.3487915252965754e-02*V(F1010) +9.6392630130299473e-02*V(F1011) -1.6118697220224676e-01*V(F1012) +2.0513812047658661e-01*V(F1013) -2.0394195612277879e-01*V(F1014) +1.3390301071492847e-01*V(F1015) -6.6962728733264879e-02*V(F1016) +6.2984103269256011e-03*V(F1017) +7.1379720555618087e-02*V(F1018) -1.5791656877208529e-01*V(F1019) +2.6399294698965831e-01*V(F1020) -3.3592141750290894e-01*V(F1021) +3.3444830901944189e-01*V(F1022) -2.1935068462474230e-01*V(F1023) +1.0993653555802498e-01*V(F1024) -9.8944895902886455e-03*V(F1025) -8.9845256100009083e-02*V(F1026) +1.9854173244333004e-01*V(F1027) -3.3185090504611581e-01*V(F1028) +4.2222642351494294e-01*V(F1029) -4.2074397849768547e-01*V(F1030) +2.7576669890656064e-01*V(F1031) -1.3839620578578615e-01*V(F1032) +1.2117812337561311e-02*V(F1033) +9.8135678249640243e-02*V(F1034) -2.1888953370740380e-01*V(F1035) +3.6636285727194590e-01*V(F1036) -4.6651094475087701e-01*V(F1037) +4.6157099101580129e-01*V(F1038) -3.0414985221025420e-01*V(F1039) +1.5099065090452327e-01*V(F1040) -1.6240280630705983e-02*V(F1041) -6.0088039907441035e-02*V(F1042) +1.3311535383519163e-01*V(F1043) -2.2257662459080951e-01*V(F1044) +2.8325376264401647e-01*V(F1045) -2.8171907173091915e-01*V(F1046) +1.8491178919546306e-01*V(F1047) -9.2529872196716711e-02*V(F1048) +8.5958069069565490e-03*V(F1049) +3.4455848816640738e-02*V(F1050) -7.7320698764726178e-02*V(F1051) +1.2952895629310926e-01*V(F1052) -1.6502196175100184e-01*V(F1053) +1.6252155409863872e-01*V(F1054) -1.0746573424480124e-01*V(F1055) +5.2972857306136212e-02*V(F1056) -6.3950148295137859e-03*V(F1057) +4.8531839038423565e-03*V(F1058) -1.2475508738315591e-02*V(F1059) +2.1285413102411836e-02*V(F1060) -2.7404915773075158e-02*V(F1061) +2.4457185036196948e-02*V(F1062) -1.7432358276749611e-02*V(F1063) +7.3237891210327184e-03*V(F1064) -3.2489796990174805e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1038)));
	I(F1039)<+( +1.6103644558309572e-11*V(reduced_0) -6.6193747005398459e-10*V(reduced_1) +4.6922186475857250e-04*V(F929) +1.2330997736647487e-03*V(F937) -2.0466479855253505e-03*V(F945) +3.2529810431721371e-03*V(F953) -4.0138837260186126e-03*V(F961) +5.1044648534287118e-03*V(F969) -2.8022831515944562e-03*V(F977) +1.9583236159286086e-03*V(F985) +8.3875958064854325e-04*V(F993) -1.2389368147897549e-03*V(F994) +3.5256136444788079e-03*V(F995) -6.5937546596242869e-03*V(F996) +8.9698215300339449e-03*V(F997) -9.2182374806806765e-03*V(F998) +6.1250343142443949e-03*V(F999) -3.2456072345156683e-03*V(F1000) +1.4544252637816418e-03*V(F1001) -1.0627158570479326e-02*V(F1002) +2.6693810536779144e-02*V(F1003) -4.9467570475236575e-02*V(F1004) +6.7440773911232391e-02*V(F1005) -6.8749982130661164e-02*V(F1006) +5.6747168304385753e-02*V(F1007) -2.7525547024720629e-02*V(F1008) +3.1462246137400271e-03*V(F1009) +2.0915608776050094e-02*V(F1010) -5.2053624315099016e-02*V(F1011) +9.6392630130302540e-02*V(F1012) -1.3143823067765040e-01*V(F1013) +1.3390301071492611e-01*V(F1014) -1.1225896008192622e-01*V(F1015) +5.4131016361389804e-02*V(F1016) -4.9214589520228764e-03*V(F1017) -3.4323527559112277e-02*V(F1018) +8.5288240340581162e-02*V(F1019) -1.5791656877209276e-01*V(F1020) +2.1533695955934121e-01*V(F1021) -2.1935068462474117e-01*V(F1022) +1.8438169823942946e-01*V(F1023) -8.8819731629096482e-02*V(F1024) +7.7232348161849328e-03*V(F1025) +4.3197747128960129e-02*V(F1026) -1.0723735137076428e-01*V(F1027) +1.9854173244334108e-01*V(F1028) -2.7073882681177319e-01*V(F1029) +2.7576669890656003e-01*V(F1030) -2.3217372065339245e-01*V(F1031) +1.1177472328525093e-01*V(F1032) -9.4522264331708648e-03*V(F1033) -4.7229223441359103e-02*V(F1034) +1.1815524403275553e-01*V(F1035) -2.1888953370739930e-01*V(F1036) +2.9844203205543302e-01*V(F1037) -3.0414985221025420e-01*V(F1038) +2.5276216722110240e-01*V(F1039) -1.2228677977898378e-01*V(F1040) +1.2727019300992693e-02*V(F1041) +2.8897860127143408e-02*V(F1042) -7.1887074895285646e-02*V(F1043) +1.3311535383519824e-01*V(F1044) -1.8151383820004058e-01*V(F1045) +1.8491178919546322e-01*V(F1046) -1.5513993604413742e-01*V(F1047) +7.4786761627821038e-02*V(F1048) -6.7146425908479390e-03*V(F1049) -1.6592857241777406e-02*V(F1050) +4.1720684862841667e-02*V(F1051) -7.7320698764723389e-02*V(F1052) +1.0541187033740819e-01*V(F1053) -1.0746573424480023e-01*V(F1054) +8.8553194943640529e-02*V(F1055) -4.2981097578859262e-02*V(F1056) +5.0227013263548885e-03*V(F1057) -2.3726485535316001e-03*V(F1058) +6.6757573014297154e-03*V(F1059) -1.2475508738299062e-02*V(F1060) +1.6974233698157638e-02*V(F1061) -1.7432358276749171e-02*V(F1062) +1.1820062175154116e-02*V(F1063) -6.2088272101446552e-03*V(F1064) +2.5853770183898880e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1039)));
	I(F1040)<+( -1.0217484823134317e-10*V(reduced_0) +4.1998791203141653e-09*V(reduced_1) -1.2410789960841558e-04*V(F929) -4.0904153191672206e-04*V(F937) +7.1576111783422380e-04*V(F945) -1.1497873353917244e-03*V(F953) +1.4282424090735514e-03*V(F961) -1.7296512346560472e-03*V(F969) +9.8294915895737666e-04*V(F977) -6.4641266712788447e-04*V(F985) -2.2362611953987888e-04*V(F993) +3.9381986815864817e-04*V(F994) -1.2389368147869349e-03*V(F995) +2.5300864571959686e-03*V(F996) -3.6529986323534983e-03*V(F997) +3.8102662271571322e-03*V(F998) -3.2456072345299534e-03*V(F999) +1.1208679121197816e-03*V(F1000) -1.1642450107351063e-03*V(F1001) +3.5884247338641906e-03*V(F1002) -1.0627158570484270e-02*V(F1003) +2.2070584474751277e-02*V(F1004) -3.2337470431991699e-02*V(F1005) +3.3936799878077697e-02*V(F1006) -2.7525547024709131e-02*V(F1007) +2.1191526906340883e-02*V(F1008) -2.8505558381749347e-03*V(F1009) -7.0911342288190573e-03*V(F1010) +2.0915608776062470e-02*V(F1011) -4.3487915252997403e-02*V(F1012) +6.3780945108817585e-02*V(F1013) -6.6962728733260951e-02*V(F1014) +5.4131016361386251e-02*V(F1015) -4.3284517882240039e-02*V(F1016) +4.6382995415464538e-03*V(F1017) +1.1644857788503157e-02*V(F1018) -3.4323527559133274e-02*V(F1019) +7.1379720555672432e-02*V(F1020) -1.0470559883579808e-01*V(F1021) +1.0993653555802264e-01*V(F1022) -8.8819731629094442e-02*V(F1023) +7.1470189352836430e-02*V(F1024) -7.3415772101087092e-03*V(F1025) -1.4661631623687398e-02*V(F1026) +4.3197747128986698e-02*V(F1027) -8.9845256100078277e-02*V(F1028) +1.3180564319026059e-01*V(F1029) -1.3839620578578407e-01*V(F1030) +1.1177472328524919e-01*V(F1031) -9.0280890067808928e-02*V(F1032) +9.0348596504280284e-03*V(F1033) +1.5975989314773082e-02*V(F1034) -4.7229223441383722e-02*V(F1035) +9.8135678249700639e-02*V(F1036) -1.4384922171560088e-01*V(F1037) +1.5099065090452327e-01*V(F1038) -1.2228677977898378e-01*V(F1039) +9.5737312196314123e-02*V(F1040) -1.1708170078776161e-02*V(F1041) -9.7993187533482965e-03*V(F1042) +2.8897860127163739e-02*V(F1043) -6.0088039907493243e-02*V(F1044) +8.8131507725365446e-02*V(F1045) -9.2529872196718946e-02*V(F1046) +7.4786761627822843e-02*V(F1047) -5.9909196731343498e-02*V(F1048) +6.3434130089135791e-03*V(F1049) +5.6003479990265285e-03*V(F1050) -1.6592857241789410e-02*V(F1051) +3.4455848816669646e-02*V(F1052) -5.0478682557654461e-02*V(F1053) +5.2972857306138418e-02*V(F1054) -4.2981097578860865e-02*V(F1055) +3.2950799039465177e-02*V(F1056) -4.5351222575479109e-03*V(F1057) +7.5870076613824438e-04*V(F1058) -2.3726485535244032e-03*V(F1059) +4.8531839038206022e-03*V(F1060) -7.0172455515808618e-03*V(F1061) +7.3237891210292351e-03*V(F1062) -6.2088272101418034e-03*V(F1063) +2.3946602765209843e-03*V(F1064) -2.0766710151231844e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1040)));
	I(F1041)<+( -1.7162181538915023e-11*V(reduced_0) +7.0544844599259872e-10*V(reduced_1) +1.2344997403684143e-02*V(F841) +5.5490041477855731e-02*V(F850) -1.0234656827769312e-01*V(F859) +1.6604798523435291e-01*V(F868) -2.0753218254435740e-01*V(F877) +2.3982648210414279e-01*V(F886) -1.4094674641122049e-01*V(F895) +8.7236017739019150e-02*V(F904) +2.2561315651472395e-02*V(F913) +2.2335460065313545e-05*V(F929) +4.6528067441006148e-05*V(F937) -7.1815408168633782e-05*V(F945) +1.1236208745142119e-04*V(F953) -1.3724863769909700e-04*V(F961) +1.8725986031899159e-04*V(F969) -9.7900755496789120e-05*V(F977) +7.4362250040071171e-05*V(F985) +3.9665046068440052e-05*V(F993) -1.2410789960868511e-04*V(F994) +4.6922186475936223e-04*V(F995) -1.0866836010402505e-03*V(F996) +1.6862909582959751e-03*V(F997) -1.8270759280599996e-03*V(F998) +1.4544252637899320e-03*V(F999) -1.1642450107414799e-03*V(F1000) +3.4848782995810379e-01*V(F1001) -4.0904153191541559e-04*V(F1002) +1.2330997736601363e-03*V(F1003) -2.5880304771580941e-03*V(F1004) +3.8137066223923517e-03*V(F1005) -4.0074615866405247e-03*V(F1006) +3.1462246137334668e-03*V(F1007) -2.8505558381698706e-03*V(F1008) +1.5934850042943145e+00*V(F1009) +7.1576111783096621e-04*V(F1010) -2.0466479855137782e-03*V(F1011) +4.1764757556294876e-03*V(F1012) -6.0551685164379025e-03*V(F1013) +6.2984103269233052e-03*V(F1014) -4.9214589520210203e-03*V(F1015) +4.6382995415449888e-03*V(F1016) -2.9460764145489251e+00*V(F1017) -1.1497873353861702e-03*V(F1018) +3.2529810431523804e-03*V(F1019) -6.5989469324708823e-03*V(F1020) +9.5336924955328785e-03*V(F1021) -9.8944895902876046e-03*V(F1022) +7.7232348161840794e-03*V(F1023) -7.3415772101079954e-03*V(F1024) +4.7818257074648729e+00*V(F1025) +1.4282424090663001e-03*V(F1026) -4.0138837259927019e-03*V(F1027) +8.1117875990452306e-03*V(F1028) -1.1692837606351560e-02*V(F1029) +1.2117812337560860e-02*V(F1030) -9.4522264331704815e-03*V(F1031) +9.0348596504276277e-03*V(F1032) -5.9780811594832750e+00*V(F1033) -1.7296512346497098e-03*V(F1034) +5.1044648534063581e-03*V(F1035) -1.0595654792579444e-02*V(F1036) +1.5515626935160903e-02*V(F1037) -1.6240280630705983e-02*V(F1038) +1.2727019300992693e-02*V(F1039) -1.1708170078776161e-02*V(F1040) +6.8939467593839066e+00*V(F1041) +9.8294915895365872e-04*V(F1042) -2.8022831515820482e-03*V(F1043) +5.7090100369710630e-03*V(F1044) -8.2689763447479671e-03*V(F1045) +8.5958069069565959e-03*V(F1046) -6.7146425908480136e-03*V(F1047) +6.3434130089137985e-03*V(F1048) -4.0576961981455142e+00*V(F1049) -6.4641266712718505e-04*V(F1050) +1.9583236159273817e-03*V(F1051) -4.1204627857532716e-03*V(F1052) +6.0805061095829905e-03*V(F1053) -6.3950148295126505e-03*V(F1054) +5.0227013263540289e-03*V(F1055) -4.5351222575475587e-03*V(F1056) +2.5045109671874917e+00*V(F1057) -2.2362611953956771e-04*V(F1058) +8.3875958064646300e-04*V(F1059) -1.9367677927716370e-03*V(F1060) +3.0010957473482216e-03*V(F1061) -3.2489796990171397e-03*V(F1062) +2.5853770183895701e-03*V(F1063) -2.0766710151227069e-03*V(F1064) +6.3746481418138401e-01*V(F1065) -6.7873832728830963e-01*V(F1066) +8.1352507506729721e-01*V(F1067) -1.0265338666637096e+00*V(F1068) +9.5697020401279265e-01*V(F1069) -6.2750135950617558e-01*V(F1070) +2.8053321164740880e-01*V(F1071) -8.1071093002738626e-02*V(F1072) -3.0559347097790939e+00*V(F1073) +3.6581291933735405e+00*V(F1074) -4.6165991725201341e+00*V(F1075) +4.3050953673361931e+00*V(F1076) -2.8244297483244698e+00*V(F1077) +1.2640135007134221e+00*V(F1078) -3.6619554293780587e-01*V(F1079) +5.6377179625022746e+00*V(F1080) -6.7474610839890410e+00*V(F1081) +8.5155378013695131e+00*V(F1082) -7.9413029653726168e+00*V(F1083) +5.2104158114922168e+00*V(F1084) -2.3321516330585661e+00*V(F1085) +6.7588006178873961e-01*V(F1086) -9.1470727936120237e+00*V(F1087) +1.0947247527196533e+01*V(F1088) -1.3815868647800935e+01*V(F1089) +1.2884315936571532e+01*V(F1090) -8.4537216541171620e+00*V(F1091) +3.7839373857024139e+00*V(F1092) -1.0966914735406796e+00*V(F1093) +1.1432607970024968e+01*V(F1094) -1.3682308359487960e+01*V(F1095) +1.7267664105234871e+01*V(F1096) -1.6103448990812858e+01*V(F1097) +1.0565964300082259e+01*V(F1098) -4.7294675860164821e+00*V(F1099) +1.3707863256516524e+00*V(F1100) -1.3208964158746213e+01*V(F1101) +1.5810691769469706e+01*V(F1102) -1.9953432333192040e+01*V(F1103) +1.8607424401621881e+01*V(F1104) -1.2208098291361225e+01*V(F1105) +5.4638115935459304e+00*V(F1106) -1.5831459537915402e+00*V(F1107) +7.7640863123611821e+00*V(F1108) -9.2923028789242164e+00*V(F1109) +1.1727231375280409e+01*V(F1110) -1.0936444836427155e+01*V(F1111) +7.1756042113834750e+00*V(F1112) -3.2117827964255818e+00*V(F1113) +9.3082249718875598e-01*V(F1114) -4.8041279220815802e+00*V(F1115) +5.7509218783356140e+00*V(F1116) -7.2577119258748750e+00*V(F1117) +6.7679694594903204e+00*V(F1118) -4.4402054810601648e+00*V(F1119) +1.9870900057630918e+00*V(F1120) -5.7565653918080428e-01*V(F1121) -1.2405482244838584e+00*V(F1122) +1.4868015713413274e+00*V(F1123) -1.8761111110637330e+00*V(F1124) +1.7490041310235764e+00*V(F1125) -1.1468835379232403e+00*V(F1126) +5.1275837740139063e-01*V(F1127) -1.4820116388537638e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1041)));
	I(F1042)<+( +9.0337518254033283e-12*V(reduced_0) -3.7133077588435739e-10*V(reduced_1) +4.6264243738130287e-04*V(F929) +1.3333374003651891e-03*V(F937) -2.5646237246495372e-03*V(F945) +4.6382995415747809e-03*V(F953) -6.3608429842495519e-03*V(F961) +6.3434130089602579e-03*V(F969) -8.0505131827195587e-03*V(F977) +3.3840325351977610e-03*V(F985) +1.6683199287535352e-03*V(F993) -3.1248944503399148e-04*V(F994) +1.1486540959715194e-03*V(F995) -1.3368026069321586e-03*V(F996) +1.2830574248050030e-03*V(F997) -8.9100511504263389e-04*V(F998) +4.3760864887299318e-04*V(F999) -1.3758649433018094e-04*V(F1000) +4.8559637520511127e-05*V(F1001) -1.0109493354993336e-02*V(F1002) +1.3084309436063632e-02*V(F1003) -1.6136915962048227e-02*V(F1004) +1.5375852633673213e-02*V(F1005) -1.0493177901412812e-02*V(F1006) +5.0520056368803723e-03*V(F1007) -1.7065300159863094e-03*V(F1008) +1.9245221493366905e-04*V(F1009) +2.3505747721625114e-02*V(F1010) -2.9476815163449185e-02*V(F1011) +3.6455293115390884e-02*V(F1012) -3.4724135635494077e-02*V(F1013) +2.3677766605217317e-02*V(F1014) -1.1388842563958404e-02*V(F1015) +3.8600722090095744e-03*V(F1016) -3.9332496294365631e-04*V(F1017) -4.3284517882210119e-02*V(F1018) +5.4131016361368169e-02*V(F1019) -6.6962728733239066e-02*V(F1020) +6.3780945108800183e-02*V(F1021) -4.3487915252988549e-02*V(F1022) +2.0915608776061169e-02*V(F1023) -7.0911342288231946e-03*V(F1024) +7.1576111783094702e-04*V(F1025) +5.9100958204391103e-02*V(F1026) -7.3959715950907348e-02*V(F1027) +9.1486378393859744e-02*V(F1028) -8.7139965789105822e-02*V(F1029) +5.9415895750796976e-02*V(F1030) -2.8576791617617472e-02*V(F1031) +9.6878521454236161e-03*V(F1032) -9.8010346304428474e-04*V(F1033) -5.9909196731254832e-02*V(F1034) +7.4786761627747528e-02*V(F1035) -9.2529872196625049e-02*V(F1036) +8.8131507725281458e-02*V(F1037) -6.0088039907441035e-02*V(F1038) +2.8897860127143408e-02*V(F1039) -9.7993187533482965e-03*V(F1040) +9.8294915895365872e-04*V(F1041) +5.6222507449796601e-02*V(F1042) -7.3888500000595214e-02*V(F1043) +9.1006536036670194e-02*V(F1044) -8.6728430420026675e-02*V(F1045) +5.9210607096955498e-02*V(F1046) -2.8520323008778093e-02*V(F1047) +9.6185239631678462e-03*V(F1048) -1.1345358740373363e-03*V(F1049) -2.6017588927802308e-02*V(F1050) +3.3589779435494696e-02*V(F1051) -4.1435353178864077e-02*V(F1052) +3.9480096190380065e-02*V(F1053) -2.6941273420232371e-02*V(F1054) +1.2970072450663476e-02*V(F1055) -4.3823457796436094e-03*V(F1056) +4.9049671310724436e-04*V(F1057) -1.9713287999938334e-03*V(F1058) +5.0384052384688568e-03*V(F1059) -5.9470857100407028e-03*V(F1060) +5.6976902291795027e-03*V(F1061) -3.9397872605320466e-03*V(F1062) +1.9256702956252530e-03*V(F1063) -6.1627578960336534e-04*V(F1064) +1.7992396063444142e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1042)));
	I(F1043)<+( -1.4237978420330956e-12*V(reduced_0) +5.8524959242060973e-11*V(reduced_1) -5.8094177966902733e-04*V(F929) -1.4672003656470182e-03*V(F937) +2.7307969556838426e-03*V(F945) -4.9214589520589986e-03*V(F953) +6.7549686939451289e-03*V(F961) -6.7146425909087445e-03*V(F969) +8.9670834715133933e-03*V(F977) -3.7156944677773783e-03*V(F985) -2.0759261374681216e-03*V(F993) +1.1486540959794480e-03*V(F994) -2.1331166577475708e-03*V(F995) +3.3303652294282456e-03*V(F996) -3.2367015538405362e-03*V(F997) +2.3800946270049290e-03*V(F998) -1.2708543266812032e-03*V(F999) +4.3760864887226145e-04*V(F1000) -1.8585023396037564e-04*V(F1001) +1.3084309436058700e-02*V(F1002) -2.6989671281221598e-02*V(F1003) +3.2651302407979380e-02*V(F1004) -3.2031430202105186e-02*V(F1005) +2.3494563860793686e-02*V(F1006) -1.2679045030191636e-02*V(F1007) +5.0520056368827679e-03*V(F1008) -5.7767882416722067e-04*V(F1009) -2.9476815163450833e-02*V(F1010) +6.1103574428924098e-02*V(F1011) -7.2968481607210617e-02*V(F1012) +7.1621883380774382e-02*V(F1013) -5.2525900790130246e-02*V(F1014) +2.8363320320734152e-02*V(F1015) -1.1388842563965707e-02*V(F1016) +1.1296879167974753e-03*V(F1017) +5.4131016361374892e-02*V(F1018) -1.1225896008198204e-01*V(F1019) +1.3390301071498881e-01*V(F1020) -1.3143823067771376e-01*V(F1021) +9.6392630130349502e-02*V(F1022) -5.2053624315126439e-02*V(F1023) +2.0915608776075099e-02*V(F1024) -2.0466479855132235e-03*V(F1025) -7.3959715950919047e-02*V(F1026) +1.5336441130050454e-01*V(F1027) -1.8298447695972694e-01*V(F1028) +1.7961415719389837e-01*V(F1029) -1.3172373965285233e-01*V(F1030) +7.1132080298620601e-02*V(F1031) -2.8576791617636706e-02*V(F1032) +2.8055399768271809e-03*V(F1033) +7.4786761627762946e-02*V(F1034) -1.5513993604411924e-01*V(F1035) +1.8491178919544918e-01*V(F1036) -1.8151383820002923e-01*V(F1037) +1.3311535383519163e-01*V(F1038) -7.1887074895285646e-02*V(F1039) +2.8897860127163739e-02*V(F1040) -2.8022831515820482e-03*V(F1041) -7.3888500000595214e-02*V(F1042) +1.5205736848385518e-01*V(F1043) -1.8508486418630127e-01*V(F1044) +1.8152521197873425e-01*V(F1045) -1.3315504617833601e-01*V(F1046) +7.1837794959702009e-02*V(F1047) -2.8520323008789674e-02*V(F1048) +3.4659468185441128e-03*V(F1049) +3.3589779435467142e-02*V(F1050) -6.9313932751971327e-02*V(F1051) +8.3769573041300976e-02*V(F1052) -8.2182665248810419e-02*V(F1053) +6.0279049525624191e-02*V(F1054) -3.2531640025217266e-02*V(F1055) +1.2970072450665462e-02*V(F1056) -1.4678004621746193e-03*V(F1057) +5.0384052384854485e-03*V(F1058) -9.6034097870232142e-03*V(F1059) +1.4123535683690847e-02*V(F1060) -1.3753688703564084e-02*V(F1061) +1.0108249650228170e-02*V(F1062) -5.4096085231760899e-03*V(F1063) +1.9256702956249956e-03*V(F1064) -6.7404527485312904e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1043)));
	I(F1044)<+( +1.6103644558352514e-11*V(reduced_0) -6.6193747005574669e-10*V(reduced_1) +7.2939268988238314e-04*V(F929) +1.8694938503926335e-03*V(F937) -3.4933305183402759e-03*V(F945) +6.2984103269728645e-03*V(F953) -8.6440003324223889e-03*V(F961) +8.5958069070353766e-03*V(F969) -1.1409439420152906e-02*V(F977) +4.7357248186925861e-03*V(F985) +2.6089078611592261e-03*V(F993) -1.3368026069408498e-03*V(F994) +3.3303652294336358e-03*V(F995) -4.5787544543284611e-03*V(F996) +5.2668379834997980e-03*V(F997) -4.0799434022388142e-03*V(F998) +2.3800946270016890e-03*V(F999) -8.9100511503999874e-04*V(F1000) +4.3234469706780347e-04*V(F1001) -1.6136915962043068e-02*V(F1002) +3.2651302407975487e-02*V(F1003) -4.9442250096370745e-02*V(F1004) +5.0117461524287671e-02*V(F1005) -3.9345658811115659e-02*V(F1006) +2.3494563860792392e-02*V(F1007) -1.0493177901418481e-02*V(F1008) +1.2097656312508504e-03*V(F1009) +3.6455293115393347e-02*V(F1010) -7.2968481607210395e-02*V(F1011) +1.1108251867045049e-01*V(F1012) -1.1180458656662590e-01*V(F1013) +8.7844049495616222e-02*V(F1014) -5.2525900790131905e-02*V(F1015) +2.3677766605235941e-02*V(F1016) -2.3109526812901994e-03*V(F1017) -6.6962728733247892e-02*V(F1018) +1.3390301071499044e-01*V(F1019) -2.0394195612289179e-01*V(F1020) +2.0513812047669205e-01*V(F1021) -1.6118697220232980e-01*V(F1022) +9.6392630130353443e-02*V(F1023) -4.3487915253024208e-02*V(F1024) +4.1764757556277269e-03*V(F1025) +9.1486378393874801e-02*V(F1026) -1.8298447695973022e-01*V(F1027) +2.7866400660715590e-01*V(F1028) -2.8034107903016697e-01*V(F1029) +2.2027381382992242e-01*V(F1030) -1.3172373965285772e-01*V(F1031) +5.9415895750846166e-02*V(F1032) -5.7285267686709267e-03*V(F1033) -9.2529872196644894e-02*V(F1034) +1.8491178919545348e-01*V(F1035) -2.8171907173091726e-01*V(F1036) +2.8325376264401542e-01*V(F1037) -2.2257662459080951e-01*V(F1038) +1.3311535383519824e-01*V(F1039) -6.0088039907493243e-02*V(F1040) +5.7090100369710630e-03*V(F1041) +9.1006536036670194e-02*V(F1042) -1.8508486418630127e-01*V(F1043) +2.7956493372853253e-01*V(F1044) -2.8432591819427971e-01*V(F1045) +2.2313267880530813e-01*V(F1046) -1.3315504617832394e-01*V(F1047) +5.9210607096981463e-02*V(F1048) -7.3233679284850023e-03*V(F1049) -4.1435353178828953e-02*V(F1050) +8.3769573041292469e-02*V(F1051) -1.2690035181685788e-01*V(F1052) +1.2856298971499755e-01*V(F1053) -1.0093697659635487e-01*V(F1054) +6.0279049525618938e-02*V(F1055) -2.6941273420236368e-02*V(F1056) +3.0689899442820382e-03*V(F1057) -5.9470857100621232e-03*V(F1058) +1.4123535683695376e-02*V(F1059) -1.9835138797286836e-02*V(F1060) +2.2196482777419577e-02*V(F1061) -1.7242346714129077e-02*V(F1062) +1.0108249650218103e-02*V(F1063) -3.9397872605287359e-03*V(F1064) +1.5557397178711622e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1044)));
	I(F1045)<+( -6.9655627186536058e-12*V(reduced_0) +2.8631822733001936e-10*V(reduced_1) -6.7236059937559472e-04*V(F929) -1.7804795124456963e-03*V(F937) +3.3553403053106856e-03*V(F945) -6.0551685164832040e-03*V(F953) +8.3083113003017042e-03*V(F961) -8.2689763448197586e-03*V(F969) +1.0832565173326055e-02*V(F977) -4.5127467930800363e-03*V(F985) -2.4101562189152389e-03*V(F993) +1.2830574248127757e-03*V(F994) -3.2367015538445707e-03*V(F995) +5.2668379835037853e-03*V(F996) -5.8234428634101150e-03*V(F997) +5.2668379834938063e-03*V(F998) -3.2367015538329329e-03*V(F999) +1.2830574248002048e-03*V(F1000) -6.7236059937293073e-04*V(F1001) +1.5375852633668648e-02*V(F1002) -3.2031430202102397e-02*V(F1003) +5.0117461524284673e-02*V(F1004) -6.0734913845576388e-02*V(F1005) +5.0117461524283896e-02*V(F1006) -3.2031430202101634e-02*V(F1007) +1.5375852633681986e-02*V(F1008) -1.7804795124395042e-03*V(F1009) -3.4724135635496430e-02*V(F1010) +7.1621883380774562e-02*V(F1011) -1.1180458656662536e-01*V(F1012) +1.3620113481957227e-01*V(F1013) -1.1180458656662511e-01*V(F1014) +7.1621883380776866e-02*V(F1015) -3.4724135635523977e-02*V(F1016) +3.3553403052859147e-03*V(F1017) +6.3780945108808398e-02*V(F1018) -1.3143823067771573e-01*V(F1019) +2.0513812047669255e-01*V(F1020) -2.5001730085841478e-01*V(F1021) +2.0513812047669194e-01*V(F1022) -1.3143823067772017e-01*V(F1023) +6.3780945108857526e-02*V(F1024) -6.0551685164348173e-03*V(F1025) -8.7139965789119839e-02*V(F1026) +1.7961415719390206e-01*V(F1027) -2.8034107903016825e-01*V(F1028) +3.4163440168378656e-01*V(F1029) -2.8034107903016647e-01*V(F1030) +1.7961415719390689e-01*V(F1031) -8.7139965789184912e-02*V(F1032) +8.3083113002340551e-03*V(F1033) +8.8131507725299915e-02*V(F1034) -1.8151383820003411e-01*V(F1035) +2.8325376264401708e-01*V(F1036) -3.4532871104265217e-01*V(F1037) +2.8325376264401647e-01*V(F1038) -1.8151383820004058e-01*V(F1039) +8.8131507725365446e-02*V(F1040) -8.2689763447479671e-03*V(F1041) -8.6728430420026675e-02*V(F1042) +1.8152521197873425e-01*V(F1043) -2.8432591819427971e-01*V(F1044) +3.4371772526925098e-01*V(F1045) -2.8432591819425018e-01*V(F1046) +1.8152521197870336e-01*V(F1047) -8.6728430420065838e-02*V(F1048) +1.0832565173280411e-02*V(F1049) +3.9480096190347473e-02*V(F1050) -8.2182665248801356e-02*V(F1051) +1.2856298971499369e-01*V(F1052) -1.5586215117855109e-01*V(F1053) +1.2856298971498786e-01*V(F1054) -8.2182665248798442e-02*V(F1055) +3.9480096190385949e-02*V(F1056) -4.5127467930778176e-03*V(F1057) +5.6976902291994451e-03*V(F1058) -1.3753688703569255e-02*V(F1059) +2.2196482777421325e-02*V(F1060) -2.5030173100993584e-02*V(F1061) +2.2196482777399277e-02*V(F1062) -1.3753688703539671e-02*V(F1063) +5.6976902291721110e-03*V(F1064) -2.4101562189080645e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1045)));
	I(F1046)<+( +1.6103644558376629e-11*V(reduced_0) -6.6193747005673982e-10*V(reduced_1) +4.3234469706943725e-04*V(F929) +1.2097656312547807e-03*V(F937) -2.3109526813059433e-03*V(F945) +4.1764757556584696e-03*V(F953) -5.7285267687138984e-03*V(F961) +5.7090100370166671e-03*V(F969) -7.3233679285138638e-03*V(F977) +3.0689899442834984e-03*V(F985) +1.5557397178755426e-03*V(F993) -8.9100511504755921e-04*V(F994) +2.3800946270076217e-03*V(F995) -4.0799434022413331e-03*V(F996) +5.2668379834974665e-03*V(F997) -4.5787544543177778e-03*V(F998) +3.3303652294183082e-03*V(F999) -1.3368026069264275e-03*V(F1000) +7.2939268987937827e-04*V(F1001) -1.0493177901409929e-02*V(F1002) +2.3494563860791854e-02*V(F1003) -3.9345658811113814e-02*V(F1004) +5.0117461524281044e-02*V(F1005) -4.9442250096364521e-02*V(F1006) +3.2651302407974703e-02*V(F1007) -1.6136915962057827e-02*V(F1008) +1.8694938503858000e-03*V(F1009) +2.3677766605218822e-02*V(F1010) -5.2525900790130385e-02*V(F1011) +8.7844049495615986e-02*V(F1012) -1.1180458656662443e-01*V(F1013) +1.1108251867044931e-01*V(F1014) -7.2968481607213850e-02*V(F1015) +3.6455293115424288e-02*V(F1016) -3.4933305183130750e-03*V(F1017) -4.3487915252993788e-02*V(F1018) +9.6392630130350876e-02*V(F1019) -1.6118697220233028e-01*V(F1020) +2.0513812047669192e-01*V(F1021) -2.0394195612289179e-01*V(F1022) +1.3390301071499700e-01*V(F1023) -6.6962728733303195e-02*V(F1024) +6.2984103269197421e-03*V(F1025) +5.9415895750805893e-02*V(F1026) -1.3172373965285489e-01*V(F1027) +2.2027381382992356e-01*V(F1028) -2.8034107903016686e-01*V(F1029) +2.7866400660715523e-01*V(F1030) -1.8298447695973780e-01*V(F1031) +9.1486378393948117e-02*V(F1032) -8.6440003323481375e-03*V(F1033) -6.0088039907452789e-02*V(F1034) +1.3311535383519499e-01*V(F1035) -2.2257662459081101e-01*V(F1036) +2.8325376264401703e-01*V(F1037) -2.8171907173091915e-01*V(F1038) +1.8491178919546322e-01*V(F1039) -9.2529872196718946e-02*V(F1040) +8.5958069069565959e-03*V(F1041) +5.9210607096955498e-02*V(F1042) -1.3315504617833601e-01*V(F1043) +2.2313267880530813e-01*V(F1044) -2.8432591819425018e-01*V(F1045) +2.7956493372848229e-01*V(F1046) -1.8508486418626105e-01*V(F1047) +9.1006536036712465e-02*V(F1048) -1.1409439420102438e-02*V(F1049) -2.6941273420211621e-02*V(F1050) +6.0279049525617932e-02*V(F1051) -1.0093697659635181e-01*V(F1052) +1.2856298971498598e-01*V(F1053) -1.2690035181684331e-01*V(F1054) +8.3769573041287057e-02*V(F1055) -4.1435353178870905e-02*V(F1056) +4.7357248186899606e-03*V(F1057) -3.9397872605447439e-03*V(F1058) +1.0108249650231766e-02*V(F1059) -1.7242346714130587e-02*V(F1060) +2.2196482777399787e-02*V(F1061) -1.9835138797250542e-02*V(F1062) +1.4123535683657845e-02*V(F1063) -5.9470857100307429e-03*V(F1064) +2.6089078611511614e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1046)));
	I(F1047)<+( -1.4237978420628834e-12*V(reduced_0) +5.8524959243285704e-11*V(reduced_1) -1.8585023396102489e-04*V(F929) -5.7767882416875373e-04*V(F937) +1.1296879168038348e-03*V(F945) -2.0466479855256723e-03*V(F953) +2.8055399768445858e-03*V(F961) -2.8022831516005490e-03*V(F969) +3.4659468185555273e-03*V(F977) -1.4678004621749932e-03*V(F985) -6.7404527485481389e-04*V(F993) +4.3760864887514630e-04*V(F994) -1.2708543266828284e-03*V(F995) +2.3800946270039528e-03*V(F996) -3.2367015538361478e-03*V(F997) +3.3303652294226116e-03*V(F998) -2.1331166577381847e-03*V(F999) +1.1486540959667725e-03*V(F1000) -5.8094177966652651e-04*V(F1001) +5.0520056368790877e-03*V(F1002) -1.2679045030190472e-02*V(F1003) +2.3494563860790633e-02*V(F1004) -3.2031430202099087e-02*V(F1005) +3.2651302407971303e-02*V(F1006) -2.6989671281218902e-02*V(F1007) +1.3084309436071093e-02*V(F1008) -1.4672003656419060e-03*V(F1009) -1.1388842563958992e-02*V(F1010) +2.8363320320734093e-02*V(F1011) -5.2525900790131516e-02*V(F1012) +7.1621883380776116e-02*V(F1013) -7.2968481607212837e-02*V(F1014) +6.1103574428929601e-02*V(F1015) -2.9476815163475945e-02*V(F1016) +2.7307969556629565e-03*V(F1017) +2.0915608776063327e-02*V(F1018) -5.2053624315126980e-02*V(F1019) +9.6392630130353471e-02*V(F1020) -1.3143823067771987e-01*V(F1021) +1.3390301071499652e-01*V(F1022) -1.1225896008199390e-01*V(F1023) +5.4131016361419593e-02*V(F1024) -4.9214589520181250e-03*V(F1025) -2.8576791617621146e-02*V(F1026) +7.1132080298621628e-02*V(F1027) -1.3172373965285802e-01*V(F1028) +1.7961415719390683e-01*V(F1029) -1.8298447695973766e-01*V(F1030) +1.5336441130052014e-01*V(F1031) -7.3959715950978208e-02*V(F1032) +6.7549686938879446e-03*V(F1033) +2.8897860127148265e-02*V(F1034) -7.1887074895287034e-02*V(F1035) +1.3311535383519868e-01*V(F1036) -1.8151383820004049e-01*V(F1037) +1.8491178919546306e-01*V(F1038) -1.5513993604413742e-01*V(F1039) +7.4786761627822843e-02*V(F1040) -6.7146425908480136e-03*V(F1041) -2.8520323008778093e-02*V(F1042) +7.1837794959702009e-02*V(F1043) -1.3315504617832394e-01*V(F1044) +1.8152521197870336e-01*V(F1045) -1.8508486418626105e-01*V(F1046) +1.5205736848382620e-01*V(F1047) -7.3888500000628035e-02*V(F1048) +8.9670834714746829e-03*V(F1049) +1.2970072450654875e-02*V(F1050) -3.2531640025214595e-02*V(F1051) +6.0279049525617613e-02*V(F1052) -8.2182665248797734e-02*V(F1053) +8.3769573041286252e-02*V(F1054) -6.9313932751965499e-02*V(F1055) +3.3589779435500247e-02*V(F1056) -3.7156944677759480e-03*V(F1057) +1.9256702956304927e-03*V(F1058) -5.4096085231775323e-03*V(F1059) +1.0108249650218530e-02*V(F1060) -1.3753688703539482e-02*V(F1061) +1.4123535683657516e-02*V(F1062) -9.6034097869916041e-03*V(F1063) +5.0384052384596784e-03*V(F1064) -2.0759261374615938e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1047)));
	I(F1048)<+( +9.0337518254410619e-12*V(reduced_0) -3.7133077588591135e-10*V(reduced_1) +4.8559637520681991e-05*V(F929) +1.9245221493410309e-04*V(F937) -3.9332496294544855e-04*V(F945) +7.1576111783445040e-04*V(F953) -9.8010346304917536e-04*V(F961) +9.8294915895884467e-04*V(F969) -1.1345358740405581e-03*V(F977) +4.9049671310746792e-04*V(F985) +1.7992396063482548e-04*V(F993) -1.3758649433101848e-04*V(F994) +4.3760864887395264e-04*V(F995) -8.9100511504369684e-04*V(F996) +1.2830574248059875e-03*V(F997) -1.3368026069328846e-03*V(F998) +1.1486540959726713e-03*V(F999) -3.1248944502926203e-04*V(F1000) +4.6264243737901699e-04*V(F1001) -1.7065300159857394e-03*V(F1002) +5.0520056368814174e-03*V(F1003) -1.0493177901415461e-02*V(F1004) +1.5375852633677243e-02*V(F1005) -1.6136915962052537e-02*V(F1006) +1.3084309436066270e-02*V(F1007) -1.0109493355005108e-02*V(F1008) +1.3333374003610297e-03*V(F1009) +3.8600722090096221e-03*V(F1010) -1.1388842563965294e-02*V(F1011) +2.3677766605234865e-02*V(F1012) -3.4724135635522221e-02*V(F1013) +3.6455293115422331e-02*V(F1014) -2.9476815163474213e-02*V(F1015) +2.3505747721658959e-02*V(F1016) -2.5646237246334104e-03*V(F1017) -7.0911342288236326e-03*V(F1018) +2.0915608776074873e-02*V(F1019) -4.3487915253023347e-02*V(F1020) +6.3780945108856055e-02*V(F1021) -6.6962728733301558e-02*V(F1022) +5.4131016361418198e-02*V(F1023) -4.3284517882273457e-02*V(F1024) +4.6382995415433408e-03*V(F1025) +9.6878521454244176e-03*V(F1026) -2.8576791617636571e-02*V(F1027) +5.9415895750845299e-02*V(F1028) -8.7139965789183357e-02*V(F1029) +9.1486378393946369e-02*V(F1030) -7.3959715950976779e-02*V(F1031) +5.9100958204477270e-02*V(F1032) -6.3608429842056027e-03*V(F1033) -9.7993187533493564e-03*V(F1034) +2.8897860127163586e-02*V(F1035) -6.0088039907492126e-02*V(F1036) +8.8131507725363475e-02*V(F1037) -9.2529872196716711e-02*V(F1038) +7.4786761627821038e-02*V(F1039) -5.9909196731343498e-02*V(F1040) +6.3434130089137985e-03*V(F1041) +9.6185239631678462e-03*V(F1042) -2.8520323008789674e-02*V(F1043) +5.9210607096981463e-02*V(F1044) -8.6728430420065838e-02*V(F1045) +9.1006536036712465e-02*V(F1046) -7.3888500000628035e-02*V(F1047) +5.6222507449854499e-02*V(F1048) -8.0505131826877317e-03*V(F1049) -4.3823457796416379e-03*V(F1050) +1.2970072450665318e-02*V(F1051) -2.6941273420237295e-02*V(F1052) +3.9480096190387823e-02*V(F1053) -4.1435353178873036e-02*V(F1054) +3.3589779435501815e-02*V(F1055) -2.6017588927833294e-02*V(F1056) +3.3840325351950449e-03*V(F1057) -6.1627578960449323e-04*V(F1058) +1.9256702956247356e-03*V(F1059) -3.9397872605273377e-03*V(F1060) +5.6976902291696547e-03*V(F1061) -5.9470857100279812e-03*V(F1062) +5.0384052384574197e-03*V(F1063) -1.9713287999790874e-03*V(F1064) +1.6683199287479038e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1048)));
	I(F1049)<+( +1.5173880019345789e-12*V(reduced_0) -6.2371966262293425e-11*V(reduced_1) -4.7235641705011639e-03*V(F841) -2.6225389338929692e-02*V(F850) +5.6004631523104427e-02*V(F859) -1.0234656827769997e-01*V(F868) +1.4000165800952524e-01*V(F877) -1.4094674641110372e-01*V(F886) +1.5174790918627010e-01*V(F895) -6.7052864879801277e-02*V(F904) -1.8190037985338772e-02*V(F913) -8.9343477605953818e-06*V(F929) -2.1676111368981397e-05*V(F937) +3.9897373479316390e-05*V(F945) -7.1815408168606162e-05*V(F953) +9.8600012798617605e-05*V(F961) -9.7900755496950245e-05*V(F969) +1.3300794296588391e-04*V(F977) -5.4855328089961329e-05*V(F985) -3.1844387903429770e-05*V(F993) +4.8559637520805827e-05*V(F994) -1.8585023396139766e-04*V(F995) +4.3234469707023908e-04*V(F996) -6.7236059937678951e-04*V(F997) +7.2939268988362108e-04*V(F998) -5.8094177966994598e-04*V(F999) +4.6264243738164623e-04*V(F1000) -1.3314691678501717e-01*V(F1001) +1.9245221493344658e-04*V(F1002) -5.7767882416641370e-04*V(F1003) +1.2097656312489199e-03*V(F1004) -1.7804795124364439e-03*V(F1005) +1.8694938503824329e-03*V(F1006) -1.4672003656391892e-03*V(F1007) +1.3333374003589276e-03*V(F1008) -7.5326141324318618e-01*V(F1009) -3.9332496294361907e-04*V(F1010) +1.1296879167972547e-03*V(F1011) -2.3109526812896569e-03*V(F1012) +3.3553403052850460e-03*V(F1013) -3.4933305183121148e-03*V(F1014) +2.7307969556621767e-03*V(F1015) -2.5646237246327720e-03*V(F1016) +1.6118088777028463e+00*V(F1017) +7.1576111783098334e-04*V(F1018) -2.0466479855131506e-03*V(F1019) +4.1764757556275135e-03*V(F1020) -6.0551685164344660e-03*V(F1021) +6.2984103269193509e-03*V(F1022) -4.9214589520177919e-03*V(F1023) +4.6382995415430051e-03*V(F1024) -2.9460764145495402e+00*V(F1025) -9.8010346304438058e-04*V(F1026) +2.8055399768272004e-03*V(F1027) -5.7285267686709119e-03*V(F1028) +8.3083113002340100e-03*V(F1029) -8.6440003323480646e-03*V(F1030) +6.7549686938878639e-03*V(F1031) -6.3608429842054144e-03*V(F1032) +4.0298073472388669e+00*V(F1033) +9.8294915895378730e-04*V(F1034) -2.8022831515820829e-03*V(F1035) +5.7090100369710682e-03*V(F1036) -8.2689763447479463e-03*V(F1037) +8.5958069069565490e-03*V(F1038) -6.7146425908479390e-03*V(F1039) +6.3434130089135791e-03*V(F1040) -4.0576961981455142e+00*V(F1041) -1.1345358740373363e-03*V(F1042) +3.4659468185441128e-03*V(F1043) -7.3233679284850023e-03*V(F1044) +1.0832565173280411e-02*V(F1045) -1.1409439420102438e-02*V(F1046) +8.9670834714746829e-03*V(F1047) -8.0505131826877317e-03*V(F1048) +4.3547863463173027e+00*V(F1049) +4.9049671310696008e-04*V(F1050) -1.4678004621743177e-03*V(F1051) +3.0689899442814554e-03*V(F1052) -4.5127467930769424e-03*V(F1053) +4.7357248186890343e-03*V(F1054) -3.7156944677752481e-03*V(F1055) +3.3840325351947869e-03*V(F1056) -1.9262169658316994e+00*V(F1057) +1.7992396063456928e-04*V(F1058) -6.7404527485312037e-04*V(F1059) +1.5557397178710532e-03*V(F1060) -2.4101562189078581e-03*V(F1061) +2.6089078611509107e-03*V(F1062) -2.0759261374613575e-03*V(F1063) +1.6683199287475350e-03*V(F1064) -5.1402341880108249e-01*V(F1065) +2.5966917119141369e-01*V(F1066) -3.1126900103591287e-01*V(F1067) +3.9276525498454778e-01*V(F1068) -3.6613961520310495e-01*V(F1069) +2.4007300960495787e-01*V(F1070) -1.0731851880721863e-01*V(F1071) +3.1007351448059228e-02*V(F1072) +1.4443079512170169e+00*V(F1073) -1.7288923608737439e+00*V(F1074) +2.1818848875605457e+00*V(F1075) -2.0346705989262248e+00*V(F1076) +1.3348884109170152e+00*V(F1077) -5.9740857093397604e-01*V(F1078) +1.7307966461067537e-01*V(F1079) -3.0849355749825906e+00*V(F1080) +3.6922341833740089e+00*V(F1081) -4.6597247262427839e+00*V(F1082) +4.3454869747965850e+00*V(F1083) -2.8511267089734305e+00*V(F1084) +1.2761330440011109e+00*V(F1085) -3.6982558639419777e-01*V(F1086) +5.6377179625020570e+00*V(F1087) -6.7474610839885019e+00*V(F1088) +8.5155378013688328e+00*V(F1089) -7.9413029653720262e+00*V(F1090) +5.2104158114918935e+00*V(F1091) -2.3321516330584737e+00*V(F1092) +6.7588006178874438e-01*V(F1093) -7.7118989013755934e+00*V(F1094) +9.2299605507130220e+00*V(F1095) -1.1648536786165383e+01*V(F1096) +1.0863022981114254e+01*V(F1097) -7.1273928865757155e+00*V(F1098) +3.1901705361089845e+00*V(F1099) -9.2453612384172623e-01*V(F1100) +7.7640863123503792e+00*V(F1101) -9.2923028789092292e+00*V(F1102) +1.1727231375261505e+01*V(F1103) -1.0936444836409880e+01*V(F1104) +7.1756042113725824e+00*V(F1105) -3.2117827964210917e+00*V(F1106) +9.3082249718767684e-01*V(F1107) -8.3564854181113510e+00*V(F1108) +1.0003691344642043e+01*V(F1109) -1.2624699053061759e+01*V(F1110) +1.1772707128430699e+01*V(F1111) -7.7235200094597909e+00*V(F1112) +3.4563568243800113e+00*V(F1113) -1.0012390693908904e+00*V(F1114) +3.6928479850077820e+00*V(F1115) -4.4204326213148537e+00*V(F1116) +5.5786508660113467e+00*V(F1117) -5.2022669611102241e+00*V(F1118) +3.4130723982053341e+00*V(F1119) -1.5274813051616922e+00*V(F1120) +4.4254745869550183e-01*V(F1121) +1.0002034477026385e+00*V(F1122) -1.1987357426135847e+00*V(F1123) +1.5126187018856461e+00*V(F1124) -1.4101417979283908e+00*V(F1125) +9.2468337540832657e-01*V(F1126) -4.1341855486373025e-01*V(F1127) +1.1949153117022747e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1049)));
	I(F1050)<+( -5.7317597788055368e-11*V(reduced_0) +2.3560297504094723e-09*V(reduced_1) -9.3637770330586725e-05*V(F929) -4.9674453089364851e-04*V(F937) +1.3333374003681251e-03*V(F945) -2.8505558381899223e-03*V(F953) +4.2791018034285698e-03*V(F961) -4.5351222575810970e-03*V(F969) +3.3840325352231548e-03*V(F977) -5.2189317662137075e-03*V(F985) -1.2203744982591078e-03*V(F993) -4.0306966875236196e-05*V(F994) -1.2257757158140511e-04*V(F995) +1.3242936452978975e-04*V(F996) -1.2836784278519189e-04*V(F997) +9.1217371110196993e-05*V(F998) -4.5943240186639353e-05*V(F999) +1.3116174362929107e-05*V(F1000) -9.2379613054344009e-06*V(F1001) +3.5255730564768360e-03*V(F1002) -4.6190892642188177e-03*V(F1003) +5.6907196388392353e-03*V(F1004) -5.4230299478416266e-03*V(F1005) +3.7020807937691112e-03*V(F1006) -1.7830400205026285e-03*V(F1007) +6.0152643982161426e-04*V(F1008) -7.0326630330999409e-05*V(F1009) -1.0109493355003595e-02*V(F1010) +1.3084309436066650e-02*V(F1011) -1.6136915962052703e-02*V(F1012) +1.5375852633677701e-02*V(F1013) -1.0493177901416092e-02*V(F1014) +5.0520056368821304e-03*V(F1015) -1.7065300159870218e-03*V(F1016) +1.9245221493347409e-04*V(F1017) +2.1191526906350958e-02*V(F1018) -2.7525547024722135e-02*V(F1019) +3.3936799878093442e-02*V(F1020) -3.2337470432007201e-02*V(F1021) +2.2070584474762407e-02*V(F1022) -1.0627158570490423e-02*V(F1023) +3.5884247338685564e-03*V(F1024) -4.0904153191549837e-04*V(F1025) -3.1296162853181861e-02*V(F1026) +4.0772832407890536e-02*V(F1027) -5.0256556780606199e-02*V(F1028) +4.7889656400398085e-02*V(F1029) -3.2687600203239214e-02*V(F1030) +1.5740749201459712e-02*V(F1031) -5.3134299892149042e-03*V(F1032) +6.1109264235051104e-04*V(F1033) +3.2950799039428935e-02*V(F1034) -4.2981097578822583e-02*V(F1035) +5.2972857306089520e-02*V(F1036) -5.0478682557609449e-02*V(F1037) +3.4455848816640738e-02*V(F1038) -1.6592857241777406e-02*V(F1039) +5.6003479990265285e-03*V(F1040) -6.4641266712718505e-04*V(F1041) -2.6017588927802308e-02*V(F1042) +3.3589779435467142e-02*V(F1043) -4.1435353178828953e-02*V(F1044) +3.9480096190347473e-02*V(F1045) -2.6941273420211621e-02*V(F1046) +1.2970072450654875e-02*V(F1047) -4.3823457796416379e-03*V(F1048) +4.9049671310696008e-04*V(F1049) +2.6319647772146713e-02*V(F1050) -3.7150668206963125e-02*V(F1051) +4.5486949517062419e-02*V(F1052) -4.3380230333166167e-02*V(F1053) +2.9668448969870000e-02*V(F1054) -1.4319841749653880e-02*V(F1055) +4.7946944692052601e-03*V(F1056) -6.7774650575620472e-04*V(F1057) +1.0854510126337184e-03*V(F1058) -3.3071380034481110e-03*V(F1059) +3.8746341783888255e-03*V(F1060) -3.7156728698667287e-03*V(F1061) +2.5750783557099482e-03*V(F1062) -1.2618433303957803e-03*V(F1063) +4.0008096577688910e-04*V(F1064) -1.2958125821493428e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1050)));
	I(F1051)<+( +9.0337518252009308e-12*V(reduced_0) -3.7133077587603823e-10*V(reduced_1) +1.1990985997439652e-04*V(F929) +5.5203073154068145e-04*V(F937) -1.4672003656508641e-03*V(F945) +3.1462246137587066e-03*V(F953) -4.7345340117916183e-03*V(F961) +5.0227013263976555e-03*V(F969) -3.7156944678125030e-03*V(F977) +6.0408610149013890e-03*V(F985) +1.5265561854678059e-03*V(F993) -1.2257757158316227e-04*V(F994) +1.9736926770900836e-04*V(F995) -4.1482517559785528e-04*V(F996) +3.9980286225890338e-04*V(F997) -2.9466365068194606e-04*V(F998) +1.5582810368554458e-04*V(F999) -4.5943240186416834e-05*V(F1000) +3.7142722947183764e-05*V(F1001) -4.6190892642191828e-03*V(F1002) +9.5102257377122600e-03*V(F1003) -1.1561690739875861e-02*V(F1004) +1.1339902817598835e-02*V(F1005) -8.3180991007197769e-03*V(F1006) +4.4879105876318949e-03*V(F1007) -1.7830400205036216e-03*V(F1008) +2.1411872627988417e-04*V(F1009) +1.3084309436073508e-02*V(F1010) -2.6989671281241447e-02*V(F1011) +3.2651302407996012e-02*V(F1012) -3.2031430202122083e-02*V(F1013) +2.3494563860806193e-02*V(F1014) -1.2679045030198484e-02*V(F1015) +5.0520056368856016e-03*V(F1016) -5.7767882416640882e-04*V(F1017) -2.7525547024739486e-02*V(F1018) +5.6747168304460777e-02*V(F1019) -6.8749982130742376e-02*V(F1020) +6.7440773911309232e-02*V(F1021) -4.9467570475289845e-02*V(F1022) +2.6693810536807000e-02*V(F1023) -1.0627158570497923e-02*V(F1024) +1.2330997736600077e-03*V(F1025) +4.0772832407918388e-02*V(F1026) -8.4019281229834875e-02*V(F1027) +1.0191350413744087e-01*V(F1028) -9.9967776638477432e-02*V(F1029) +7.3326999193576201e-02*V(F1030) -3.9566668435574645e-02*V(F1031) +1.5740749201470925e-02*V(F1032) -1.8487093869712003e-03*V(F1033) -4.2981097578853648e-02*V(F1034) +8.8553194943653379e-02*V(F1035) -1.0746573424481480e-01*V(F1036) +1.0541187033741807e-01*V(F1037) -7.7320698764726178e-02*V(F1038) +4.1720684862841667e-02*V(F1039) -1.6592857241789410e-02*V(F1040) +1.9583236159273817e-03*V(F1041) +3.3589779435494696e-02*V(F1042) -6.9313932751971327e-02*V(F1043) +8.3769573041292469e-02*V(F1044) -8.2182665248801356e-02*V(F1045) +6.0279049525617932e-02*V(F1046) -3.2531640025214595e-02*V(F1047) +1.2970072450665318e-02*V(F1048) -1.4678004621743177e-03*V(F1049) -3.7150668206963125e-02*V(F1050) +7.5652771930513493e-02*V(F1051) -9.4631794266125918e-02*V(F1052) +9.2709021763199395e-02*V(F1053) -6.8025628148178072e-02*V(F1054) +3.6654286128368768e-02*V(F1055) -1.4319841749655740e-02*V(F1056) +2.2006255403094126e-03*V(F1057) -3.3071380034609688e-03*V(F1058) +6.2178695577219650e-03*V(F1059) -9.4387201874711699e-03*V(F1060) +9.1817270866599229e-03*V(F1061) -6.7500531793453309e-03*V(F1062) +3.6080016415809416e-03*V(F1063) -1.2618433303954819e-03*V(F1064) +4.9143500088615684e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1051)));
	I(F1052)<+( -1.0217484823103990e-10*V(reduced_0) +4.1998791203016781e-09*V(reduced_1) -1.5024321163327009e-04*V(F929) -7.0257597382163302e-04*V(F937) +1.8694938503974858e-03*V(F945) -4.0074615866730647e-03*V(F953) +6.0288064682514440e-03*V(F961) -6.3950148295686803e-03*V(F969) +4.7357248187368528e-03*V(F977) -7.6522665330035792e-03*V(F985) -1.9174208547319742e-03*V(F993) +1.3242936453168556e-04*V(F994) -4.1482517559911268e-04*V(F995) +5.1913996809335250e-04*V(F996) -6.7311326044387494e-04*V(F997) +5.1555244466489482e-04*V(F998) -2.9466365068118636e-04*V(F999) +9.1217371109453691e-05*V(F1000) -8.7913248543646815e-05*V(F1001) +5.6907196388399726e-03*V(F1002) -1.1561690739875412e-02*V(F1003) +1.7472310525492182e-02*V(F1004) -1.7758062754138784e-02*V(F1005) +1.3937166050110150e-02*V(F1006) -8.3180991007192149e-03*V(F1007) +3.7020807937714340e-03*V(F1008) -4.5165492052998385e-04*V(F1009) -1.6136915962061515e-02*V(F1010) +3.2651302407997969e-02*V(F1011) -4.9442250096403108e-02*V(F1012) +5.0117461524314892e-02*V(F1013) -3.9345658811137628e-02*V(F1014) +2.3494563860805583e-02*V(F1015) -1.0493177901424525e-02*V(F1016) +1.2097656312487918e-03*V(F1017) +3.3936799878115570e-02*V(F1018) -6.8749982130747719e-02*V(F1019) +1.0404342861367871e-01*V(F1020) -1.0554685481274312e-01*V(F1021) +8.2854306795437718e-02*V(F1022) -4.9467570475288339e-02*V(F1023) +2.2070584474780563e-02*V(F1024) -2.5880304771573681e-03*V(F1025) -5.0256556780641663e-02*V(F1026) +1.0191350413744951e-01*V(F1027) -1.5415571834841518e-01*V(F1028) +1.5648578162785134e-01*V(F1029) -1.2283238896177402e-01*V(F1030) +7.3326999193573605e-02*V(F1031) -3.2687600203266283e-02*V(F1032) +3.8870419017512331e-03*V(F1033) +5.2972857306129086e-02*V(F1034) -1.0746573424482443e-01*V(F1035) +1.6252155409866348e-01*V(F1036) -1.6502196175101530e-01*V(F1037) +1.2952895629310926e-01*V(F1038) -7.7320698764723389e-02*V(F1039) +3.4455848816669646e-02*V(F1040) -4.1204627857532716e-03*V(F1041) -4.1435353178864077e-02*V(F1042) +8.3769573041300976e-02*V(F1043) -1.2690035181685788e-01*V(F1044) +1.2856298971499369e-01*V(F1045) -1.0093697659635181e-01*V(F1046) +6.0279049525617613e-02*V(F1047) -2.6941273420237295e-02*V(F1048) +3.0689899442814554e-03*V(F1049) +4.5486949517062419e-02*V(F1050) -9.4631794266125918e-02*V(F1051) +1.4137100565482788e-01*V(F1052) -1.4589578849927959e-01*V(F1053) +1.1431062728733891e-01*V(F1054) -6.8025628148160711e-02*V(F1055) +2.9668448969870420e-02*V(F1056) -4.7874144682642185e-03*V(F1057) +3.8746341784053847e-03*V(F1058) -9.4387201874747747e-03*V(F1059) +1.3105908237567793e-02*V(F1060) -1.4883869880864778e-02*V(F1061) +1.1544565643956544e-02*V(F1062) -6.7500531793376894e-03*V(F1063) +2.5750783557071774e-03*V(F1064) -1.1394259373464137e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1052)));
	I(F1053)<+( +4.4195294490218836e-11*V(reduced_0) -1.8166397871748024e-09*V(reduced_1) +1.3785270902713271e-04*V(F929) +6.6744273932930781e-04*V(F937) -1.7804795124501721e-03*V(F945) +3.8137066224220892e-03*V(F953) -5.7337344109375911e-03*V(F961) +6.0805061096339472e-03*V(F969) -4.5127467931204727e-03*V(F977) +7.1954222897440403e-03*V(F985) +1.7691165199546837e-03*V(F993) -1.2836784278688032e-04*V(F994) +3.9980286225982760e-04*V(F995) -6.7311326044482069e-04*V(F996) +6.8441402779725055e-04*V(F997) -6.7311326044250451e-04*V(F998) +3.9980286225713276e-04*V(F999) -1.2836784278386960e-04*V(F1000) +1.3785270902669572e-04*V(F1001) -5.4230299478423682e-03*V(F1002) +1.1339902817598677e-02*V(F1003) -1.7758062754138278e-02*V(F1004) +2.1477993663506299e-02*V(F1005) -1.7758062754137081e-02*V(F1006) +1.1339902817597263e-02*V(F1007) -5.4230299478451949e-03*V(F1008) +6.6744273932586461e-04*V(F1009) +1.5375852633685896e-02*V(F1010) -3.2031430202124275e-02*V(F1011) +5.0117461524315704e-02*V(F1012) -6.0734913845615052e-02*V(F1013) +5.0117461524311485e-02*V(F1014) -3.2031430202119765e-02*V(F1015) +1.5375852633690897e-02*V(F1016) -1.7804795124361599e-03*V(F1017) -3.2337470432027747e-02*V(F1018) +6.7440773911314936e-02*V(F1019) -1.0554685481274549e-01*V(F1020) +1.2783330793692488e-01*V(F1021) -1.0554685481273528e-01*V(F1022) +6.7440773911303722e-02*V(F1023) -3.2337470432035546e-02*V(F1024) +3.8137066223909101e-03*V(F1025) +4.7889656400430997e-02*V(F1026) -9.9967776638486619e-02*V(F1027) +1.5648578162785531e-01*V(F1028) -1.8943653587640358e-01*V(F1029) +1.5648578162783885e-01*V(F1030) -9.9967776638468314e-02*V(F1031) +4.7889656400440211e-02*V(F1032) -5.7337344108902783e-03*V(F1033) -5.0478682557646183e-02*V(F1034) +1.0541187033742837e-01*V(F1035) -1.6502196175101974e-01*V(F1036) +1.9973097337668994e-01*V(F1037) -1.6502196175100184e-01*V(F1038) +1.0541187033740819e-01*V(F1039) -5.0478682557654461e-02*V(F1040) +6.0805061095829905e-03*V(F1041) +3.9480096190380065e-02*V(F1042) -8.2182665248810419e-02*V(F1043) +1.2856298971499755e-01*V(F1044) -1.5586215117855109e-01*V(F1045) +1.2856298971498598e-01*V(F1046) -8.2182665248797734e-02*V(F1047) +3.9480096190387823e-02*V(F1048) -4.5127467930769424e-03*V(F1049) -4.3380230333166167e-02*V(F1050) +9.2709021763199395e-02*V(F1051) -1.4589578849927959e-01*V(F1052) +1.7448510902979164e-01*V(F1053) -1.4589578849924509e-01*V(F1054) +9.2709021763157873e-02*V(F1055) -4.3380230333163697e-02*V(F1056) +7.1954222897301027e-03*V(F1057) -3.7156728698821352e-03*V(F1058) +9.1817270866639752e-03*V(F1059) -1.4883869880866230e-02*V(F1060) +1.6607710640909556e-02*V(F1061) -1.4883869880849420e-02*V(F1062) +9.1817270866414117e-03*V(F1063) -3.7156728698607101e-03*V(F1064) +1.7691165199494709e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1053)));
	I(F1054)<+( -1.0217484823119205e-10*V(reduced_0) +4.1998791203079424e-09*V(reduced_1) -8.7913248543911157e-05*V(F929) -4.5165492053216147e-04*V(F937) +1.2097656312576564e-03*V(F945) -2.5880304771770868e-03*V(F953) +3.8870419017811475e-03*V(F961) -4.1204627857854810e-03*V(F969) +3.0689899443089924e-03*V(F977) -4.7874144682728791e-03*V(F985) -1.1394259373495898e-03*V(F993) +9.1217371111266572e-05*V(F994) -2.9466365068256194e-04*V(F995) +5.1555244466548863e-04*V(F996) -6.7311326044338141e-04*V(F997) +5.1913996809091424e-04*V(F998) -4.1482517559555070e-04*V(F999) +1.3242936452823094e-04*V(F1000) -1.5024321163277144e-04*V(F1001) +3.7020807937695869e-03*V(F1002) -8.3180991007196885e-03*V(F1003) +1.3937166050109872e-02*V(F1004) -1.7758062754136515e-02*V(F1005) +1.7472310525489233e-02*V(F1006) -1.1561690739873709e-02*V(F1007) +5.6907196388430916e-03*V(F1008) -7.0257597381783896e-04*V(F1009) -1.0493177901421310e-02*V(F1010) +2.3494563860807706e-02*V(F1011) -3.9345658811138294e-02*V(F1012) +5.0117461524311777e-02*V(F1013) -4.9442250096396953e-02*V(F1014) +3.2651302407992605e-02*V(F1015) -1.6136915962067112e-02*V(F1016) +1.8694938503820784e-03*V(F1017) +2.2070584474775484e-02*V(F1018) -4.9467570475293765e-02*V(F1019) +8.2854306795439633e-02*V(F1020) -1.0554685481273643e-01*V(F1021) +1.0404342861366439e-01*V(F1022) -6.8749982130734244e-02*V(F1023) +3.3936799878124320e-02*V(F1024) -4.0074615866387822e-03*V(F1025) -3.2687600203260177e-02*V(F1026) +7.3326999193582557e-02*V(F1027) -1.2283238896177710e-01*V(F1028) +1.5648578162784091e-01*V(F1029) -1.5415571834839240e-01*V(F1030) +1.0191350413742745e-01*V(F1031) -5.0256556780651995e-02*V(F1032) +6.0288064681994170e-03*V(F1033) +3.4455848816664102e-02*V(F1034) -7.7320698764733270e-02*V(F1035) +1.2952895629311276e-01*V(F1036) -1.6502196175100406e-01*V(F1037) +1.6252155409863872e-01*V(F1038) -1.0746573424480023e-01*V(F1039) +5.2972857306138418e-02*V(F1040) -6.3950148295126505e-03*V(F1041) -2.6941273420232371e-02*V(F1042) +6.0279049525624191e-02*V(F1043) -1.0093697659635487e-01*V(F1044) +1.2856298971498786e-01*V(F1045) -1.2690035181684331e-01*V(F1046) +8.3769573041286252e-02*V(F1047) -4.1435353178873036e-02*V(F1048) +4.7357248186890343e-03*V(F1049) +2.9668448969870000e-02*V(F1050) -6.8025628148178072e-02*V(F1051) +1.1431062728733891e-01*V(F1052) -1.4589578849924509e-01*V(F1053) +1.4137100565476840e-01*V(F1054) -9.4631794266071712e-02*V(F1055) +4.5486949517057701e-02*V(F1056) -7.6522665329878696e-03*V(F1057) +2.5750783557197533e-03*V(F1058) -6.7500531793481438e-03*V(F1059) +1.1544565643957764e-02*V(F1060) -1.4883869880849918e-02*V(F1061) +1.3105908237540306e-02*V(F1062) -9.4387201874461379e-03*V(F1063) +3.8746341783808085e-03*V(F1064) -1.9174208547261087e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1054)));
	I(F1055)<+( +9.0337518253899819e-12*V(reduced_0) -3.7133077588381119e-10*V(reduced_1) +3.7142722947287780e-05*V(F929) +2.1411872628075159e-04*V(F937) -5.7767882416999471e-04*V(F945) +1.2330997736679922e-03*V(F953) -1.8487093869833143e-03*V(F961) +1.9583236159404320e-03*V(F969) -1.4678004621855093e-03*V(F977) +2.2006255403126287e-03*V(F985) +4.9143500088737700e-04*V(F993) -4.5943240187109775e-05*V(F994) +1.5582810368592288e-04*V(F995) -2.9466365068172765e-04*V(F996) +3.9980286225791030e-04*V(F997) -4.1482517559659186e-04*V(F998) +1.9736926770683397e-04*V(F999) -1.2257757158012399e-04*V(F1000) +1.1990985997396996e-04*V(F1001) -1.7830400205028042e-03*V(F1002) +4.4879105876317630e-03*V(F1003) -8.3180991007188679e-03*V(F1004) +1.1339902817596691e-02*V(F1005) -1.1561690739872930e-02*V(F1006) +9.5102257377106258e-03*V(F1007) -4.6190892642217971e-03*V(F1008) +5.5203073153776928e-04*V(F1009) +5.0520056368842901e-03*V(F1010) -1.2679045030199107e-02*V(F1011) +2.3494563860805819e-02*V(F1012) -3.2031430202119772e-02*V(F1013) +3.2651302407992598e-02*V(F1014) -2.6989671281238758e-02*V(F1015) +1.3084309436077976e-02*V(F1016) -1.4672003656389045e-03*V(F1017) -1.0627158570495843e-02*V(F1018) +2.6693810536808679e-02*V(F1019) -4.9467570475289158e-02*V(F1020) +6.7440773911304139e-02*V(F1021) -6.8749982130734702e-02*V(F1022) +5.6747168304453963e-02*V(F1023) -2.7525547024746366e-02*V(F1024) +3.1462246137320465e-03*V(F1025) +1.5740749201468403e-02*V(F1026) -3.9566668435577379e-02*V(F1027) +7.3326999193575007e-02*V(F1028) -9.9967776638469077e-02*V(F1029) +1.0191350413742836e-01*V(F1030) -8.4019281229823273e-02*V(F1031) +4.0772832407926438e-02*V(F1032) -4.7345340117511316e-03*V(F1033) -1.6592857241787093e-02*V(F1034) +4.1720684862844713e-02*V(F1035) -7.7320698764724943e-02*V(F1036) +1.0541187033740908e-01*V(F1037) -1.0746573424480124e-01*V(F1038) +8.8553194943640529e-02*V(F1039) -4.2981097578860865e-02*V(F1040) +5.0227013263540289e-03*V(F1041) +1.2970072450663476e-02*V(F1042) -3.2531640025217266e-02*V(F1043) +6.0279049525618938e-02*V(F1044) -8.2182665248798442e-02*V(F1045) +8.3769573041287057e-02*V(F1046) -6.9313932751965499e-02*V(F1047) +3.3589779435501815e-02*V(F1048) -3.7156944677752481e-03*V(F1049) -1.4319841749653880e-02*V(F1050) +3.6654286128368768e-02*V(F1051) -6.8025628148160711e-02*V(F1052) +9.2709021763157873e-02*V(F1053) -9.4631794266071712e-02*V(F1054) +7.5652771930468113e-02*V(F1055) -3.7150668206957914e-02*V(F1056) +6.0408610148893404e-03*V(F1057) -1.2618433303998304e-03*V(F1058) +3.6080016415820856e-03*V(F1059) -6.7500531793380798e-03*V(F1060) +9.1817270866413614e-03*V(F1061) -9.4387201874460130e-03*V(F1062) +6.2178695576979130e-03*V(F1063) -3.3071380034407813e-03*V(F1064) +1.5265561854630402e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1055)));
	I(F1056)<+( -5.7317597788295470e-11*V(reduced_0) +2.3560297504193604e-09*V(reduced_1) -9.2379613054614822e-06*V(F929) -7.0326630331238042e-05*V(F937) +1.9245221493445852e-04*V(F945) -4.0904153191768342e-04*V(F953) +6.1109264235382035e-04*V(F961) -6.4641266713074492e-04*V(F969) +4.9049671311001124e-04*V(F977) -6.7774650575709323e-04*V(F985) -1.2958125821520874e-04*V(F993) +1.3116174363120492e-05*V(F994) -4.5943240186826696e-05*V(F995) +9.1217371110357659e-05*V(F996) -1.2836784278528538e-04*V(F997) +1.3242936452981230e-04*V(F998) -1.2257757158156641e-04*V(F999) -4.0306966876479959e-05*V(F1000) -9.3637770330170811e-05*V(F1001) +6.0152643982158823e-04*V(F1002) -1.7830400205033048e-03*V(F1003) +3.7020807937706564e-03*V(F1004) -5.4230299478439511e-03*V(F1005) +5.6907196388416986e-03*V(F1006) -4.6190892642205498e-03*V(F1007) +3.5255730564805652e-03*V(F1008) -4.9674453089135120e-04*V(F1009) -1.7065300159874984e-03*V(F1010) +5.0520056368855504e-03*V(F1011) -1.0493177901424084e-02*V(F1012) +1.5375852633690099e-02*V(F1013) -1.6136915962066213e-02*V(F1014) +1.3084309436077260e-02*V(F1015) -1.0109493355015394e-02*V(F1016) +1.3333374003589036e-03*V(F1017) +3.5884247338697946e-03*V(F1018) -1.0627158570497995e-02*V(F1019) +2.2070584474779928e-02*V(F1020) -3.2337470432034304e-02*V(F1021) +3.3936799878122904e-02*V(F1022) -2.7525547024745318e-02*V(F1023) +2.1191526906375043e-02*V(F1024) -2.8505558381693992e-03*V(F1025) -5.3134299892169026e-03*V(F1026) +1.5740749201471102e-02*V(F1027) -3.2687600203265416e-02*V(F1028) +4.7889656400438442e-02*V(F1029) -5.0256556780649997e-02*V(F1030) +4.0772832407924973e-02*V(F1031) -3.1296162853216604e-02*V(F1032) +4.2791018033974081e-03*V(F1033) +5.6003479990287593e-03*V(F1034) -1.6592857241789615e-02*V(F1035) +3.4455848816668695e-02*V(F1036) -5.0478682557652518e-02*V(F1037) +5.2972857306136212e-02*V(F1038) -4.2981097578859262e-02*V(F1039) +3.2950799039465177e-02*V(F1040) -4.5351222575475587e-03*V(F1041) -4.3823457796436094e-03*V(F1042) +1.2970072450665462e-02*V(F1043) -2.6941273420236368e-02*V(F1044) +3.9480096190385949e-02*V(F1045) -4.1435353178870905e-02*V(F1046) +3.3589779435500247e-02*V(F1047) -2.6017588927833294e-02*V(F1048) +3.3840325351947869e-03*V(F1049) +4.7946944692052601e-03*V(F1050) -1.4319841749655740e-02*V(F1051) +2.9668448969870420e-02*V(F1052) -4.3380230333163697e-02*V(F1053) +4.5486949517057701e-02*V(F1054) -3.7150668206957914e-02*V(F1055) +2.6319647772156320e-02*V(F1056) -5.2189317662022661e-03*V(F1057) +4.0008096577777257e-04*V(F1058) -1.2618433303953338e-03*V(F1059) +2.5750783557062242e-03*V(F1060) -3.7156728698590135e-03*V(F1061) +3.8746341783789011e-03*V(F1062) -3.3071380034392361e-03*V(F1063) +1.0854510126219593e-03*V(F1064) -1.2203744982549861e-03*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1056)));
	I(F1057)<+( -9.6275652535344975e-12*V(reduced_0) +3.9573937214205803e-10*V(reduced_1) +8.1421589690944165e-04*V(F841) +9.4406820861813248e-03*V(F850) -2.6225389338915616e-02*V(F859) +5.5490041477828059e-02*V(F868) -8.2592781392201095e-02*V(F877) +8.7236017738803129e-02*V(F886) -6.7052864879608154e-02*V(F895) +8.4503425920764944e-02*V(F904) +1.2817649433548951e-02*V(F913) +1.8540892493944891e-06*V(F929) +8.1820851129444436e-06*V(F937) -2.1676111369008735e-05*V(F945) +4.6528067441072616e-05*V(F953) -7.0073393906842601e-05*V(F961) +7.4362250040391323e-05*V(F969) -5.4855328090245600e-05*V(F977) +9.0704632433246686e-05*V(F985) +2.3451838612821807e-05*V(F993) -9.2379613055042472e-06*V(F994) +3.7142722947430149e-05*V(F995) -8.7913248544234886e-05*V(F996) +1.3785270902762759e-04*V(F997) -1.5024321163379625e-04*V(F998) +1.1990985997479617e-04*V(F999) -9.3637770330807916e-05*V(F1000) +2.2793247462369413e-02*V(F1001) -7.0326630330961882e-05*V(F1002) +2.1411872627970680e-04*V(F1003) -4.5165492052955185e-04*V(F1004) +6.6744273932517690e-04*V(F1005) -7.0257597381708067e-04*V(F1006) +5.5203073153715465e-04*V(F1007) -4.9674453089085984e-04*V(F1008) +2.7097058718033756e-01*V(F1009) +1.9245221493353366e-04*V(F1010) -5.7767882416643408e-04*V(F1011) +1.2097656312488167e-03*V(F1012) -1.7804795124361870e-03*V(F1013) +1.8694938503820994e-03*V(F1014) -1.4672003656389088e-03*V(F1015) +1.3333374003588333e-03*V(F1016) -7.5326141324328966e-01*V(F1017) -4.0904153191567483e-04*V(F1018) +1.2330997736601859e-03*V(F1019) -2.5880304771577090e-03*V(F1020) +3.8137066223914158e-03*V(F1021) -4.0074615866393147e-03*V(F1022) +3.1462246137324459e-03*V(F1023) -2.8505558381695323e-03*V(F1024) +1.5934850042948538e+00*V(F1025) +6.1109264235080182e-04*V(F1026) -1.8487093869715193e-03*V(F1027) +3.8870419017518602e-03*V(F1028) -5.7337344108912185e-03*V(F1029) +6.0288064682004171e-03*V(F1030) -4.7345340117518871e-03*V(F1031) +4.2791018033977142e-03*V(F1032) -2.3713716671042837e+00*V(F1033) -6.4641266712751053e-04*V(F1034) +1.9583236159277429e-03*V(F1035) -4.1204627857539828e-03*V(F1036) +6.0805061095840600e-03*V(F1037) -6.3950148295137859e-03*V(F1038) +5.0227013263548885e-03*V(F1039) -4.5351222575479109e-03*V(F1040) +2.5045109671874917e+00*V(F1041) +4.9049671310724436e-04*V(F1042) -1.4678004621746193e-03*V(F1043) +3.0689899442820382e-03*V(F1044) -4.5127467930778176e-03*V(F1045) +4.7357248186899606e-03*V(F1046) -3.7156944677759480e-03*V(F1047) +3.3840325351950449e-03*V(F1048) -1.9262169658316994e+00*V(F1049) -6.7774650575620472e-04*V(F1050) +2.2006255403094126e-03*V(F1051) -4.7874144682642185e-03*V(F1052) +7.1954222897301027e-03*V(F1053) -7.6522665329878696e-03*V(F1054) +6.0408610148893404e-03*V(F1055) -5.2189317662022661e-03*V(F1056) +2.4166824845092889e+00*V(F1057) -1.2958125821504004e-04*V(F1058) +4.9143500088617929e-04*V(F1059) -1.1394259373464005e-03*V(F1060) +1.7691165199494243e-03*V(F1061) -1.9174208547260397e-03*V(F1062) +1.5265561854629589e-03*V(F1063) -1.2203744982547816e-03*V(F1064) +3.6169917351301795e-01*V(F1065) -4.4730592030579101e-02*V(F1066) +5.3646381170449009e-02*V(F1067) -6.7688275658198779e-02*V(F1068) +6.3091844913033629e-02*V(F1069) -4.1359721802556051e-02*V(F1070) +1.8481154365070713e-02*V(F1071) -5.3344260213144656e-03*V(F1072) -5.1989012973015292e-01*V(F1073) +6.2236132981630099e-01*V(F1074) -7.8542363452001707e-01*V(F1075) +7.3242075296189590e-01*V(F1076) -4.8050943506634347e-01*V(F1077) +2.1503530713282298e-01*V(F1078) -6.2293090286016317e-02*V(F1079) +1.4443079512155130e+00*V(F1080) -1.7288923608716089e+00*V(F1081) +2.1818848875578509e+00*V(F1082) -2.0346705989237690e+00*V(F1083) +1.3348884109154748e+00*V(F1084) -5.9740857093334931e-01*V(F1085) +1.7307966461053051e-01*V(F1086) -3.0559347097756597e+00*V(F1087) +3.6581291933685463e+00*V(F1088) -4.6165991725138307e+00*V(F1089) +4.3050953673304644e+00*V(F1090) -2.8244297483209002e+00*V(F1091) +1.2640135007119888e+00*V(F1092) -3.6619554293748791e-01*V(F1093) +4.5484537331081345e+00*V(F1094) -5.4448309999257196e+00*V(F1095) +6.8714266222220237e+00*V(F1096) -6.4077585080819421e+00*V(F1097) +4.2038941218990304e+00*V(F1098) -1.8813435065560218e+00*V(F1099) +5.4502753184085795e-01*V(F1100) -4.8041279220615376e+00*V(F1101) +5.7509218783077891e+00*V(F1102) -7.2577119258397724e+00*V(F1103) +6.7679694594582456e+00*V(F1104) -4.4402054810399463e+00*V(F1105) +1.9870900057547551e+00*V(F1106) -5.7565653917880133e-01*V(F1107) +3.6928479849898763e+00*V(F1108) -4.4204326212899971e+00*V(F1109) +5.5786508659799914e+00*V(F1110) -5.2022669610815768e+00*V(F1111) +3.4130723981872748e+00*V(F1112) -1.5274813051542457e+00*V(F1113) +4.4254745869371237e-01*V(F1114) -4.6518939306643530e+00*V(F1115) +5.5703004214491649e+00*V(F1116) -7.0295422306778033e+00*V(F1117) +6.5547312364182835e+00*V(F1118) -4.2997862139964340e+00*V(F1119) +1.9237948238564284e+00*V(F1120) -5.5700564244035977e-01*V(F1121) -7.0470066542437104e-01*V(F1122) +8.4466575174894420e-01*V(F1123) -1.0658251080187602e+00*V(F1124) +9.9359234044720290e-01*V(F1125) -6.5150779991304153e-01*V(F1126) +2.9125925821898130e-01*V(F1127) -8.4166396703507076e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1057)));
	I(F1058)<+( -9.6275652534925214e-12*V(reduced_0) +3.9573937214032819e-10*V(reduced_1) +2.6240007055832141e-05*V(F929) -9.3637770330119203e-05*V(F937) +4.6264243737897395e-04*V(F945) -1.1642450107353468e-03*V(F953) +1.8767806733315715e-03*V(F961) -2.0766710151101896e-03*V(F969) +1.6683199287375031e-03*V(F977) -1.2203744982467969e-03*V(F985) -2.2978930368975061e-04*V(F993) -3.2926095641133688e-05*V(F994) +8.1284118988685078e-05*V(F995) -9.6099672714761733e-05*V(F996) +9.2050681536583708e-05*V(F997) -6.3619145475489851e-05*V(F998) +3.1078179641562106e-05*V(F999) -9.9661963915226199e-06*V(F1000) +2.8408644186023409e-06*V(F1001) -4.0306966875253523e-05*V(F1002) -1.2257757158353982e-04*V(F1003) +1.3242936453225225e-04*V(F1004) -1.2836784278747693e-04*V(F1005) +9.1217371111701500e-05*V(F1006) -4.5943240187321120e-05*V(F1007) +1.3116174363140750e-05*V(F1008) -9.2379613055142168e-06*V(F1009) -3.1248944503231915e-04*V(F1010) +1.1486540959793120e-03*V(F1011) -1.3368026069409892e-03*V(F1012) +1.2830574248131387e-03*V(F1013) -8.9100511504793629e-04*V(F1014) +4.3760864887535056e-04*V(F1015) -1.3758649433088835e-04*V(F1016) +4.8559637520849290e-05*V(F1017) +1.1208679121264397e-03*V(F1018) -3.2456072345457220e-03*V(F1019) +3.8102662271763212e-03*V(F1020) -3.6529986323704197e-03*V(F1021) +2.5300864572059870e-03*V(F1022) -1.2389368147902200e-03*V(F1023) +3.9381986815832236e-04*V(F1024) -1.2410789960880377e-04*V(F1025) -2.0394903559909769e-03*V(F1026) +5.4788750971462305e-03*V(F1027) -6.4525304869662318e-03*V(F1028) +6.1836997393591754e-03*V(F1029) -4.2787459229757111e-03*V(F1030) +2.0929481965848377e-03*V(F1031) -6.6793683675444172e-04*V(F1032) +2.0139015165110803e-04*V(F1033) +2.3946602765395016e-03*V(F1034) -6.2088272101768361e-03*V(F1035) +7.3237891210719093e-03*V(F1036) -7.0172455516180950e-03*V(F1037) +4.8531839038423565e-03*V(F1038) -2.3726485535316001e-03*V(F1039) +7.5870076613824438e-04*V(F1040) -2.2362611953956771e-04*V(F1041) -1.9713287999938334e-03*V(F1042) +5.0384052384854485e-03*V(F1043) -5.9470857100621232e-03*V(F1044) +5.6976902291994451e-03*V(F1045) -3.9397872605447439e-03*V(F1046) +1.9256702956304927e-03*V(F1047) -6.1627578960449323e-04*V(F1048) +1.7992396063456928e-04*V(F1049) +1.0854510126337184e-03*V(F1050) -3.3071380034609688e-03*V(F1051) +3.8746341784053847e-03*V(F1052) -3.7156728698821352e-03*V(F1053) +2.5750783557197533e-03*V(F1054) -1.2618433303998304e-03*V(F1055) +4.0008096577777257e-04*V(F1056) -1.2958125821504004e-04*V(F1057) +3.8117561396533344e-03*V(F1058) -4.4514068866207184e-03*V(F1059) +5.5416390854537536e-03*V(F1060) -5.2742547628196954e-03*V(F1061) +3.5894236219924584e-03*V(F1062) -1.7225618257696786e-03*V(F1063) +5.8849704229693722e-04*V(F1064) -4.4966273202097477e-05*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1058)));
	I(F1059)<+( +1.5173880018942558e-12*V(reduced_0) -6.2371966260635342e-11*V(reduced_1) -3.2607821878342064e-05*V(F929) +1.1990985997373256e-04*V(F937) -5.8094177966577884e-04*V(F945) +1.4544252637802750e-03*V(F953) -2.3393245184715090e-03*V(F961) +2.5853770183702604e-03*V(F969) -2.0759261374458829e-03*V(F977) +1.5265561854507371e-03*V(F985) +2.0632419467173430e-04*V(F993) +8.1284118988768901e-05*V(F994) -1.5539227965561964e-04*V(F995) +2.2694770948227468e-04*V(F996) -2.2105763918010027e-04*V(F997) +1.6245537981417630e-04*V(F998) -8.6964610646911986e-05*V(F999) +3.1078179641501073e-05*V(F1000) -1.0610425158786053e-05*V(F1001) -1.2257757158251381e-04*V(F1002) +1.9736926771028756e-04*V(F1003) -4.1482517560091127e-04*V(F1004) +3.9980286226175694e-04*V(F1005) -2.9466365068400973e-04*V(F1006) +1.5582810368664775e-04*V(F1007) -4.5943240186874428e-05*V(F1008) +3.7142722947467195e-05*V(F1009) +1.1486540959745031e-03*V(F1010) -2.1331166577493151e-03*V(F1011) +3.3303652294373195e-03*V(F1012) -3.2367015538487891e-03*V(F1013) +2.3800946270108470e-03*V(F1014) -1.2708543266843455e-03*V(F1015) +4.3760864887357903e-04*V(F1016) -1.8585023396159382e-04*V(F1017) -3.2456072345339727e-03*V(F1018) +6.1250343142711583e-03*V(F1019) -9.2182374807164846e-03*V(F1020) +8.9698215300646911e-03*V(F1021) -6.5937546596410686e-03*V(F1022) +3.5256136444825111e-03*V(F1023) -1.2389368147860220e-03*V(F1024) +4.6922186475989696e-04*V(F1025) +5.4788750971275215e-03*V(F1026) -1.0400157501539076e-02*V(F1027) +1.5442306066725203e-02*V(F1028) -1.5033015799817593e-02*V(F1029) +1.1049467580361780e-02*V(F1030) -5.9111151681674762e-03*V(F1031) +2.0929481965782449e-03*V(F1032) -7.5745524304116508e-04*V(F1033) -6.2088272101562458e-03*V(F1034) +1.1820062175193626e-02*V(F1035) -1.7432358276796463e-02*V(F1036) +1.6974233698194823e-02*V(F1037) -1.2475508738315591e-02*V(F1038) +6.6757573014297154e-03*V(F1039) -2.3726485535244032e-03*V(F1040) +8.3875958064646300e-04*V(F1041) +5.0384052384688568e-03*V(F1042) -9.6034097870232142e-03*V(F1043) +1.4123535683695376e-02*V(F1044) -1.3753688703569255e-02*V(F1045) +1.0108249650231766e-02*V(F1046) -5.4096085231775323e-03*V(F1047) +1.9256702956247356e-03*V(F1048) -6.7404527485312037e-04*V(F1049) -3.3071380034481110e-03*V(F1050) +6.2178695577219650e-03*V(F1051) -9.4387201874747747e-03*V(F1052) +9.1817270866639752e-03*V(F1053) -6.7500531793481438e-03*V(F1054) +3.6080016415820856e-03*V(F1055) -1.2618433303953338e-03*V(F1056) +4.9143500088617929e-04*V(F1057) -4.4514068866207184e-03*V(F1058) +9.3351664268828925e-03*V(F1059) -1.0807802604666968e-02*V(F1060) +1.0622334139023963e-02*V(F1061) -7.7874183131302309e-03*V(F1062) +4.2113458293804983e-03*V(F1063) -1.7225618257718290e-03*V(F1064) +1.0900943000863256e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1059)));
	I(F1060)<+( -1.7162181538861163e-11*V(reduced_0) +7.0544844599037878e-10*V(reduced_1) +4.0985446700106702e-05*V(F929) -1.5024321163243924e-04*V(F937) +7.2939268987831131e-04*V(F945) -1.8270759280476989e-03*V(F953) +2.9393978040740893e-03*V(F961) -3.2489796989925170e-03*V(F969) +2.6089078611311791e-03*V(F977) -1.9174208547104504e-03*V(F985) -2.6991596145816912e-04*V(F993) -9.6099672714828994e-05*V(F994) +2.2694770948238326e-04*V(F995) -3.1953312876070852e-04*V(F996) +3.5640058388531595e-04*V(F997) -2.7694707013067860e-04*V(F998) +1.6245537981398841e-04*V(F999) -6.3619145475292716e-05*V(F1000) +2.4461740597775463e-05*V(F1001) +1.3242936453089377e-04*V(F1002) -4.1482517560070104e-04*V(F1003) +5.1913996809639239e-04*V(F1004) -6.7311326044809249e-04*V(F1005) +5.1555244466808833e-04*V(F1006) -2.9466365068310323e-04*V(F1007) +9.1217371110379017e-05*V(F1008) -8.7913248544314263e-05*V(F1009) -1.3368026069347672e-03*V(F1010) +3.3303652294360375e-03*V(F1011) -4.5787544543349178e-03*V(F1012) +5.2668379835115941e-03*V(F1013) -4.0799434022475321e-03*V(F1014) +2.3800946270069309e-03*V(F1015) -8.9100511504261622e-04*V(F1016) +4.3234469707069514e-04*V(F1017) +3.8102662271611389e-03*V(F1018) -9.2182374807133066e-03*V(F1019) +1.2839021189557875e-02*V(F1020) -1.4523087773088847e-02*V(F1021) +1.1269245558919947e-02*V(F1022) -6.5937546596315701e-03*V(F1023) +2.5300864571933296e-03*V(F1024) -1.0866836010414997e-03*V(F1025) -6.4525304869420671e-03*V(F1026) +1.5442306066720127e-02*V(F1027) -2.1612346860109322e-02*V(F1028) +2.4294049093402416e-02*V(F1029) -1.8863101486289943e-02*V(F1030) +1.1049467580346712e-02*V(F1031) -4.2787459229557982e-03*V(F1032) +1.7508346670173302e-03*V(F1033) +7.3237891210453133e-03*V(F1034) -1.7432358276790866e-02*V(F1035) +2.4457185036242300e-02*V(F1036) -2.7404915773102053e-02*V(F1037) +2.1285413102411836e-02*V(F1038) -1.2475508738299062e-02*V(F1039) +4.8531839038206022e-03*V(F1040) -1.9367677927716370e-03*V(F1041) -5.9470857100407028e-03*V(F1042) +1.4123535683690847e-02*V(F1043) -1.9835138797286836e-02*V(F1044) +2.2196482777421325e-02*V(F1045) -1.7242346714130587e-02*V(F1046) +1.0108249650218530e-02*V(F1047) -3.9397872605273377e-03*V(F1048) +1.5557397178710532e-03*V(F1049) +3.8746341783888255e-03*V(F1050) -9.4387201874711699e-03*V(F1051) +1.3105908237567793e-02*V(F1052) -1.4883869880866230e-02*V(F1053) +1.1544565643957764e-02*V(F1054) -6.7500531793380798e-03*V(F1055) +2.5750783557062242e-03*V(F1056) -1.1394259373464005e-03*V(F1057) +5.5416390854537536e-03*V(F1058) -1.0807802604666968e-02*V(F1059) +1.6666397600335319e-02*V(F1060) -1.6488858081063949e-02*V(F1061) +1.2980437300827211e-02*V(F1062) -7.7874183131336865e-03*V(F1063) +3.5894236219986236e-03*V(F1064) -2.0034567745646299e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1060)));
	I(F1061)<+( +7.4234283714273725e-12*V(reduced_0) -3.0513871425298054e-10*V(reduced_1) -3.7875113416851186e-05*V(F929) +1.3785270902638019e-04*V(F937) -6.7236059937189369e-04*V(F945) +1.6862909582846283e-03*V(F953) -2.7143538346503320e-03*V(F961) +3.0010957473254546e-03*V(F969) -2.4101562188896140e-03*V(F977) +1.7691165199350198e-03*V(F985) +2.7150868036163991e-04*V(F993) +9.2050681536637850e-05*V(F994) -2.2105763918016787e-04*V(F995) +3.5640058388540838e-04*V(F996) -4.0284946553413223e-04*V(F997) +3.5640058388498956e-04*V(F998) -2.2105763917966862e-04*V(F999) +9.2050681536237712e-05*V(F1000) -3.7875113416911163e-05*V(F1001) -1.2836784278620533e-04*V(F1002) +3.9980286226147017e-04*V(F1003) -6.7311326044805248e-04*V(F1004) +6.8441402780118903e-04*V(F1005) -6.7311326044664670e-04*V(F1006) +3.9980286225972856e-04*V(F1007) -1.2836784278522935e-04*V(F1008) +1.3785270902774371e-04*V(F1009) +1.2830574248073442e-03*V(F1010) -3.2367015538473020e-03*V(F1011) +5.2668379835111162e-03*V(F1012) -5.8234428634190019e-03*V(F1013) +5.2668379835052546e-03*V(F1014) -3.2367015538399893e-03*V(F1015) +1.2830574248040528e-03*V(F1016) -6.7236059937748904e-04*V(F1017) -3.6529986323562851e-03*V(F1018) +8.9698215300610465e-03*V(F1019) -1.4523087773087638e-02*V(F1020) +1.6251171047212121e-02*V(F1021) -1.4523087773073417e-02*V(F1022) +8.9698215300433332e-03*V(F1023) -3.6529986323487760e-03*V(F1024) +1.6862909582979005e-03*V(F1025) +6.1836997393366769e-03*V(F1026) -1.5033015799811773e-02*V(F1027) +2.4294049093400470e-02*V(F1028) -2.7307439062195068e-02*V(F1029) +2.4294049093377897e-02*V(F1030) -1.5033015799783703e-02*V(F1031) +6.1836997393251028e-03*V(F1032) -2.7143538346711816e-03*V(F1033) -7.0172455515933362e-03*V(F1034) +1.6974233698188408e-02*V(F1035) -2.7404915773099902e-02*V(F1036) +3.0874272979805790e-02*V(F1037) -2.7404915773075158e-02*V(F1038) +1.6974233698157638e-02*V(F1039) -7.0172455515808618e-03*V(F1040) +3.0010957473482216e-03*V(F1041) +5.6976902291795027e-03*V(F1042) -1.3753688703564084e-02*V(F1043) +2.2196482777419577e-02*V(F1044) -2.5030173100993584e-02*V(F1045) +2.2196482777399787e-02*V(F1046) -1.3753688703539482e-02*V(F1047) +5.6976902291696547e-03*V(F1048) -2.4101562189078581e-03*V(F1049) -3.7156728698667287e-03*V(F1050) +9.1817270866599229e-03*V(F1051) -1.4883869880864778e-02*V(F1052) +1.6607710640909556e-02*V(F1053) -1.4883869880849918e-02*V(F1054) +9.1817270866413614e-03*V(F1055) -3.7156728698590135e-03*V(F1056) +1.7691165199494243e-03*V(F1057) -5.2742547628196954e-03*V(F1058) +1.0622334139023963e-02*V(F1059) -1.6488858081063949e-02*V(F1060) +2.0344204240358894e-02*V(F1061) -1.6488858081069688e-02*V(F1062) +1.0622334139031806e-02*V(F1063) -5.2742547628301141e-03*V(F1064) +2.7150868035612436e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1061)));
	I(F1062)<+( -1.7162181538886634e-11*V(reduced_0) +7.0544844599142775e-10*V(reduced_1) +2.4461740597735212e-05*V(F929) -8.7913248543442646e-05*V(F937) +4.3234469706711782e-04*V(F945) -1.0866836010330130e-03*V(F953) +1.7508346670039991e-03*V(F961) -1.9367677927570792e-03*V(F969) +1.5557397178593878e-03*V(F977) -1.1394259373371924e-03*V(F985) -2.0034567745999901e-04*V(F993) -6.3619145475523800e-05*V(F994) +1.6245537981422043e-04*V(F995) -2.7694707013073389e-04*V(F996) +3.5640058388508285e-04*V(F997) -3.1953312876014289e-04*V(F998) +2.2694770948171862e-04*V(F999) -9.6099672714358668e-05*V(F1000) +4.0985446700168122e-05*V(F1001) +9.1217371110891438e-05*V(F1002) -2.9466365068380910e-04*V(F1003) +5.1555244466803434e-04*V(F1004) -6.7311326044668931e-04*V(F1005) +5.1913996809395163e-04*V(F1006) -4.1482517559833509e-04*V(F1007) +1.3242936452968515e-04*V(F1008) -1.5024321163391581e-04*V(F1009) -8.9100511504424664e-04*V(F1010) +2.3800946270098153e-03*V(F1011) -4.0799434022471114e-03*V(F1012) +5.2668379835051392e-03*V(F1013) -4.5787544543242241e-03*V(F1014) +3.3303652294261275e-03*V(F1015) -1.3368026069305837e-03*V(F1016) +7.2939268988436690e-04*V(F1017) +2.5300864571969868e-03*V(F1018) -6.5937546596385324e-03*V(F1019) +1.1269245558918894e-02*V(F1020) -1.4523087773073089e-02*V(F1021) +1.2839021189531855e-02*V(F1022) -9.2182374806893171e-03*V(F1023) +3.8102662271515199e-03*V(F1024) -1.8270759280620578e-03*V(F1025) -4.2787459229613857e-03*V(F1026) +1.1049467580357740e-02*V(F1027) -1.8863101486288260e-02*V(F1028) +2.4294049093377360e-02*V(F1029) -2.1612346860068007e-02*V(F1030) +1.5442306066682097e-02*V(F1031) -6.4525304869271858e-03*V(F1032) +2.9393978040966398e-03*V(F1033) +4.8531839038265939e-03*V(F1034) -1.2475508738311139e-02*V(F1035) +2.1285413102409976e-02*V(F1036) -2.7404915773074544e-02*V(F1037) +2.4457185036196948e-02*V(F1038) -1.7432358276749171e-02*V(F1039) +7.3237891210292351e-03*V(F1040) -3.2489796990171397e-03*V(F1041) -3.9397872605320466e-03*V(F1042) +1.0108249650228170e-02*V(F1043) -1.7242346714129077e-02*V(F1044) +2.2196482777399277e-02*V(F1045) -1.9835138797250542e-02*V(F1046) +1.4123535683657516e-02*V(F1047) -5.9470857100279812e-03*V(F1048) +2.6089078611509107e-03*V(F1049) +2.5750783557099482e-03*V(F1050) -6.7500531793453309e-03*V(F1051) +1.1544565643956544e-02*V(F1052) -1.4883869880849420e-02*V(F1053) +1.3105908237540306e-02*V(F1054) -9.4387201874460130e-03*V(F1055) +3.8746341783789011e-03*V(F1056) -1.9174208547260397e-03*V(F1057) +3.5894236219924584e-03*V(F1058) -7.7874183131302309e-03*V(F1059) +1.2980437300827211e-02*V(F1060) -1.6488858081069684e-02*V(F1061) +1.6666397600345259e-02*V(F1062) -1.0807802604677133e-02*V(F1063) +5.5416390854656451e-03*V(F1064) -2.6991596145215326e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1062)));
	I(F1063)<+( +1.5173880019258846e-12*V(reduced_0) -6.2371966261935773e-11*V(reduced_1) -1.0610425158767526e-05*V(F929) +3.7142722947098363e-05*V(F937) -1.8585023396007377e-04*V(F945) +4.6922186475628614e-04*V(F953) -7.5745524303548982e-04*V(F961) +8.3875958064026385e-04*V(F969) -6.7404527484815223e-04*V(F977) +4.9143500088226488e-04*V(F985) +1.0900943001010196e-04*V(F993) +3.1078179641579271e-05*V(F994) -8.6964610646944119e-05*V(F995) +1.6245537981404522e-04*V(F996) -2.2105763917975546e-04*V(F997) +2.2694770948183534e-04*V(F998) -1.5539227965512744e-04*V(F999) +8.1284118988352743e-05*V(F1000) -3.2607821878386618e-05*V(F1001) -4.5943240186989428e-05*V(F1002) +1.5582810368657885e-04*V(F1003) -2.9466365068312193e-04*V(F1004) +3.9980286225981199e-04*V(F1005) -4.1482517559845273e-04*V(F1006) +1.9736926770811292e-04*V(F1007) -1.2257757158144102e-04*V(F1008) +1.1990985997488543e-04*V(F1009) +4.3760864887382883e-04*V(F1010) -1.2708543266839361e-03*V(F1011) +2.3800946270068264e-03*V(F1012) -3.2367015538400743e-03*V(F1013) +3.3303652294262632e-03*V(F1014) -2.1331166577399281e-03*V(F1015) +1.1486540959707761e-03*V(F1016) -5.8094177967052158e-04*V(F1017) -1.2389368147865067e-03*V(F1018) +3.5256136444814998e-03*V(F1019) -6.5937546596312848e-03*V(F1020) +8.9698215300434980e-03*V(F1021) -9.2182374806895895e-03*V(F1022) +6.1250343142484186e-03*V(F1023) -3.2456072345253650e-03*V(F1024) +1.4544252637915293e-03*V(F1025) +2.0929481965789266e-03*V(F1026) -5.9111151681658603e-03*V(F1027) +1.1049467580346249e-02*V(F1028) -1.5033015799783942e-02*V(F1029) +1.5442306066682506e-02*V(F1030) -1.0400157501503037e-02*V(F1031) +5.4788750971141737e-03*V(F1032) -2.3393245184891889e-03*V(F1033) -2.3726485535250953e-03*V(F1034) +6.6757573014279339e-03*V(F1035) -1.2475508738298547e-02*V(F1036) +1.6974233698157898e-02*V(F1037) -1.7432358276749611e-02*V(F1038) +1.1820062175154116e-02*V(F1039) -6.2088272101418034e-03*V(F1040) +2.5853770183895701e-03*V(F1041) +1.9256702956252530e-03*V(F1042) -5.4096085231760899e-03*V(F1043) +1.0108249650218103e-02*V(F1044) -1.3753688703539671e-02*V(F1045) +1.4123535683657845e-02*V(F1046) -9.6034097869916041e-03*V(F1047) +5.0384052384574197e-03*V(F1048) -2.0759261374613575e-03*V(F1049) -1.2618433303957803e-03*V(F1050) +3.6080016415809416e-03*V(F1051) -6.7500531793376894e-03*V(F1052) +9.1817270866414117e-03*V(F1053) -9.4387201874461379e-03*V(F1054) +6.2178695576979130e-03*V(F1055) -3.3071380034392361e-03*V(F1056) +1.5265561854629589e-03*V(F1057) -1.7225618257696786e-03*V(F1058) +4.2113458293804983e-03*V(F1059) -7.7874183131336865e-03*V(F1060) +1.0622334139031806e-02*V(F1061) -1.0807802604677133e-02*V(F1062) +9.3351664268923260e-03*V(F1063) -4.4514068866303748e-03*V(F1064) +2.0632419466708882e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1063)));
	I(F1064)<+( -9.6275652535327382e-12*V(reduced_0) +3.9573937214198441e-10*V(reduced_1) +2.8408644185972053e-06*V(F929) -9.2379613054139349e-06*V(F937) +4.8559637520436229e-05*V(F945) -1.2410789960782349e-04*V(F953) +2.0139015164956809e-04*V(F961) -2.2362611953788609e-04*V(F969) +1.7992396063322194e-04*V(F977) -1.2958125821397703e-04*V(F985) -4.4966273202522748e-05*V(F993) -9.9661963915362486e-06*V(F994) +3.1078179641547958e-05*V(F995) -6.3619145475401570e-05*V(F996) +9.2050681536410005e-05*V(F997) -9.6099672714551222e-05*V(F998) +8.1284118988526636e-05*V(F999) -3.2926095640907232e-05*V(F1000) +2.6240007055842248e-05*V(F1001) +1.3116174363077505e-05*V(F1002) -4.5943240186929994e-05*V(F1003) +9.1217371110560594e-05*V(F1004) -1.2836784278553277e-04*V(F1005) +1.3242936453002516e-04*V(F1006) -1.2257757158173264e-04*V(F1007) -4.0306966876497523e-05*V(F1008) -9.3637770330878131e-05*V(F1009) -1.3758649433056423e-04*V(F1010) +4.3760864887367119e-04*V(F1011) -8.9100511504306193e-04*V(F1012) +1.2830574248048282e-03*V(F1013) -1.3368026069314556e-03*V(F1014) +1.1486540959714949e-03*V(F1015) -3.1248944502758531e-04*V(F1016) +4.6264243738207276e-04*V(F1017) +3.9381986815752623e-04*V(F1018) -1.2389368147862232e-03*V(F1019) +2.5300864571943609e-03*V(F1020) -3.6529986323505796e-03*V(F1021) +3.8102662271535465e-03*V(F1022) -3.2456072345270291e-03*V(F1023) +1.1208679121154481e-03*V(F1024) -1.1642450107426665e-03*V(F1025) -6.6793683675317266e-04*V(F1026) +2.0929481965785558e-03*V(F1027) -4.2787459229574184e-03*V(F1028) +6.1836997393279400e-03*V(F1029) -6.4525304869303734e-03*V(F1030) +5.4788750971167879e-03*V(F1031) -2.0394903559738994e-03*V(F1032) +1.8767806733430458e-03*V(F1033) +7.5870076613684630e-04*V(F1034) -2.3726485535247397e-03*V(F1035) +4.8531839038223681e-03*V(F1036) -7.0172455515839591e-03*V(F1037) +7.3237891210327184e-03*V(F1038) -6.2088272101446552e-03*V(F1039) +2.3946602765209843e-03*V(F1040) -2.0766710151227069e-03*V(F1041) -6.1627578960336534e-04*V(F1042) +1.9256702956249956e-03*V(F1043) -3.9397872605287359e-03*V(F1044) +5.6976902291721110e-03*V(F1045) -5.9470857100307429e-03*V(F1046) +5.0384052384596784e-03*V(F1047) -1.9713287999790874e-03*V(F1048) +1.6683199287475350e-03*V(F1049) +4.0008096577688910e-04*V(F1050) -1.2618433303954819e-03*V(F1051) +2.5750783557071774e-03*V(F1052) -3.7156728698607101e-03*V(F1053) +3.8746341783808085e-03*V(F1054) -3.3071380034407813e-03*V(F1055) +1.0854510126219593e-03*V(F1056) -1.2203744982547816e-03*V(F1057) +5.8849704229693722e-04*V(F1058) -1.7225618257718290e-03*V(F1059) +3.5894236219986236e-03*V(F1060) -5.2742547628301141e-03*V(F1061) +5.5416390854656451e-03*V(F1062) -4.4514068866303748e-03*V(F1063) +3.8117561396636547e-03*V(F1064) -2.2978930368633472e-04*V(F1065))+ ddt(( +1.0000000000000000e-03*V(Vol_F1064)));
	I(F1065)<+( -1.6171301011846701e-12*V(reduced_0) +6.6471847664693781e-11*V(reduced_1) -2.8873010745445078e-04*V(F841) +8.1421589691667198e-04*V(F850) -4.7235641705309899e-03*V(F859) +1.2344997403757796e-02*V(F868) -2.0218928184656454e-02*V(F877) +2.2561315651632583e-02*V(F886) -1.8190037985467471e-02*V(F895) +1.2817649433646728e-02*V(F904) +7.3803523869918541e-03*V(F913) -5.0001210058953920e-07*V(F929) +1.8540892493906053e-06*V(F937) -8.9343477605749496e-06*V(F945) +2.2335460065265719e-05*V(F953) -3.5902216976633386e-05*V(F961) +3.9665046068222730e-05*V(F969) -3.1844387903254767e-05*V(F977) +2.3451838612686773e-05*V(F985) +2.8204506865857605e-06*V(F993) +2.8408644186091891e-06*V(F994) -1.0610425158813253e-05*V(F995) +2.4461740597840949e-05*V(F996) -3.7875113417015186e-05*V(F997) +4.0985446700282668e-05*V(F998) -3.2607821878479181e-05*V(F999) +2.6240007055914869e-05*V(F1000) -8.1618219912577943e-03*V(F1001) -9.2379613055114046e-06*V(F1002) +3.7142722947490126e-05*V(F1003) -8.7913248544375317e-05*V(F1004) +1.3785270902784283e-04*V(F1005) -1.5024321163402651e-04*V(F1006) +1.1990985997497711e-04*V(F1007) -9.3637770330962130e-05*V(F1008) +2.2793247462478235e-02*V(F1009) +4.8559637520814372e-05*V(F1010) -1.8585023396160572e-04*V(F1011) +4.3234469707074941e-04*V(F1012) -6.7236059937758510e-04*V(F1013) +7.2939268988447934e-04*V(F1014) -5.8094177967062230e-04*V(F1015) +4.6264243738220547e-04*V(F1016) -1.3314691678541182e-01*V(F1017) -1.2410789960871536e-04*V(F1018) +4.6922186475991263e-04*V(F1019) -1.0866836010416001e-03*V(F1020) +1.6862909582980837e-03*V(F1021) -1.8270759280622755e-03*V(F1022) +1.4544252637917286e-03*V(F1023) -1.1642450107429540e-03*V(F1024) +3.4848782995908656e-01*V(F1025) +2.0139015165096614e-04*V(F1026) -7.5745524304118503e-04*V(F1027) +1.7508346670174774e-03*V(F1028) -2.7143538346714518e-03*V(F1029) +2.9393978040969633e-03*V(F1030) -2.3393245184894882e-03*V(F1031) +1.8767806733434888e-03*V(F1032) -5.7110275049066650e-01*V(F1033) -2.2362611953941072e-04*V(F1034) +8.3875958064648132e-04*V(F1035) -1.9367677927717897e-03*V(F1036) +3.0010957473485048e-03*V(F1037) -3.2489796990174805e-03*V(F1038) +2.5853770183898880e-03*V(F1039) -2.0766710151231844e-03*V(F1040) +6.3746481418138401e-01*V(F1041) +1.7992396063444142e-04*V(F1042) -6.7404527485312904e-04*V(F1043) +1.5557397178711622e-03*V(F1044) -2.4101562189080645e-03*V(F1045) +2.6089078611511614e-03*V(F1046) -2.0759261374615938e-03*V(F1047) +1.6683199287479038e-03*V(F1048) -5.1402341880108249e-01*V(F1049) -1.2958125821493428e-04*V(F1050) +4.9143500088615684e-04*V(F1051) -1.1394259373464137e-03*V(F1052) +1.7691165199494709e-03*V(F1053) -1.9174208547261087e-03*V(F1054) +1.5265561854630402e-03*V(F1055) -1.2203744982549861e-03*V(F1056) +3.6169917351301795e-01*V(F1057) -4.4966273202097477e-05*V(F1058) +1.0900943000863256e-04*V(F1059) -2.0034567745646299e-04*V(F1060) +2.7150868035612441e-04*V(F1061) -2.6991596145215321e-04*V(F1062) +2.0632419466708882e-04*V(F1063) -2.2978930368633472e-04*V(F1064) +2.1218123068871242e-01*V(F1065) +1.5876720007536069e-02*V(F1066) -1.9027648214159337e-02*V(F1067) +2.4010008153534254e-02*V(F1068) -2.2383513850097334e-02*V(F1069) +1.4677870162777528e-02*V(F1070) -6.5624914638974562e-03*V(F1071) +1.8968674457655978e-03*V(F1072) -4.4730592031115742e-02*V(F1073) +5.3646381171154209e-02*V(F1074) -6.7688275659088984e-02*V(F1075) +6.3091844913853320e-02*V(F1076) -4.1359721803080562e-02*V(F1077) +1.8481154365293819e-02*V(F1078) -5.3344260213721729e-03*V(F1079) +2.5966917119370470e-01*V(F1080) -3.1126900103895039e-01*V(F1081) +3.9276525498838244e-01*V(F1082) -3.6613961520663107e-01*V(F1083) +2.4007300960720915e-01*V(F1084) -1.0731851880817167e-01*V(F1085) +3.1007351448302817e-02*V(F1086) -6.7873832729395556e-01*V(F1087) +8.1352507507477956e-01*V(F1088) -1.0265338666731529e+00*V(F1089) +9.5697020402147759e-01*V(F1090) -6.2750135951172148e-01*V(F1091) +2.8053321164975736e-01*V(F1092) -8.1071093003339229e-02*V(F1093) +1.1117172853006849e+00*V(F1094) -1.3324279958977725e+00*V(F1095) +1.6813115340829645e+00*V(F1096) -1.5673934159089140e+00*V(F1097) +1.0277850647878515e+00*V(F1098) -4.5950216691857532e-01*V(F1099) +1.3280266943976277e-01*V(F1100) -1.2405482244986872e+00*V(F1101) +1.4868015713619123e+00*V(F1102) -1.8761111110896991e+00*V(F1103) +1.7490041310473008e+00*V(F1104) -1.1468835379381965e+00*V(F1105) +5.1275837740755703e-01*V(F1106) -1.4820116388685858e-01*V(F1107) +1.0002034477145527e+00*V(F1108) -1.1987357426301226e+00*V(F1109) +1.5126187019065074e+00*V(F1110) -1.4101417979474520e+00*V(F1111) +9.2468337542034318e-01*V(F1112) -4.1341855486868473e-01*V(F1113) +1.1949153117141832e-01*V(F1114) -7.0470066543342713e-01*V(F1115) +8.4466575176151582e-01*V(F1116) -1.0658251080346182e+00*V(F1117) +9.9359234046169242e-01*V(F1118) -6.5150779992217600e-01*V(F1119) +2.9125925822274734e-01*V(F1120) -8.4166396704412241e-02*V(F1121) -4.0647969641375681e-01*V(F1122) +4.8655123218523327e-01*V(F1123) -6.1403691502352009e-01*V(F1124) +5.7261308637626662e-01*V(F1125) -3.7568152508672376e-01*V(F1126) +1.6813624311741415e-01*V(F1127) -4.8716018197298407e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1065)));
	I(F1066)<+( +1.7241501778367512e-26*V(reduced_0) -1.2617523441830060e-26*V(reduced_1) -4.8716018198280711e-02*V(F841) -8.4166396705750476e-02*V(F850) +1.1949153117332456e-01*V(F859) -1.4820116388918556e-01*V(F868) +1.3280266944182778e-01*V(F877) -8.1071093004572506e-02*V(F886) +3.1007351448755039e-02*V(F895) -5.3344260214249935e-03*V(F904) +1.8968674458047184e-03*V(F913) -4.0647969641212228e-01*V(F1001) -7.0470066542805976e-01*V(F1009) +1.0002034477069333e+00*V(F1017) -1.2405482244889241e+00*V(F1025) +1.1117172852917792e+00*V(F1033) -6.7873832728830963e-01*V(F1041) +2.5966917119141369e-01*V(F1049) -4.4730592030579101e-02*V(F1057) +1.5876720007536069e-02*V(F1065) +1.3359359025685111e+00*V(F1066) -2.1357119500361557e+00*V(F1067) +2.5903544832044378e+00*V(F1068) -2.4732690172401854e+00*V(F1069) +1.6962796511462628e+00*V(F1070) -8.2139940274012346e-01*V(F1071) +2.7187014590553799e-01*V(F1072) +2.2650310113449983e+00*V(F1073) -3.6484455267862423e+00*V(F1074) +4.4227315642084992e+00*V(F1075) -4.2231038139635224e+00*V(F1076) +2.8968612733562220e+00*V(F1077) -1.4030239693566107e+00*V(F1078) +4.6407211752016236e-01*V(F1079) -3.2203643453749811e+00*V(F1080) +5.1842269825232012e+00*V(F1081) -6.2847041650736379e+00*V(F1082) +6.0010019363115594e+00*V(F1083) -4.1163689600503712e+00*V(F1084) +1.9936340981467391e+00*V(F1085) -6.5945939705599488e-01*V(F1086) +3.9935572664555616e+00*V(F1087) -6.4292883031723997e+00*V(F1088) +7.7940291484003490e+00*V(F1089) -7.4421970545134579e+00*V(F1090) +5.1049583447562261e+00*V(F1091) -2.4724296790878277e+00*V(F1092) +8.1783268484088345e-01*V(F1093) -3.5774577275386896e+00*V(F1094) +5.7601541176957696e+00*V(F1095) -6.9827935374333796e+00*V(F1096) +6.6675892952143876e+00*V(F1097) -4.5736305629758824e+00*V(F1098) +2.2151044657507040e+00*V(F1099) -7.3270606768475510e-01*V(F1100) +2.1825526913247422e+00*V(F1101) -3.5150593883994765e+00*V(F1102) +4.2610836446517375e+00*V(F1103) -4.0687467160283592e+00*V(F1104) +2.7909701919012004e+00*V(F1105) -1.3517332011914962e+00*V(F1106) +4.4711280154476035e-01*V(F1107) -8.3349773499799962e-01*V(F1108) +1.3431914359845822e+00*V(F1109) -1.6281950360274735e+00*V(F1110) +1.5547099078559015e+00*V(F1111) -1.0664722263744062e+00*V(F1112) +5.1652557487968775e-01*V(F1113) -1.7084205755744505e-01*V(F1114) +1.4236836453337579e-01*V(F1115) -2.3009393378746912e-01*V(F1116) +2.7885881365916282e-01*V(F1117) -2.6627991136631640e-01*V(F1118) +1.8266917629278140e-01*V(F1119) -8.8478608014197421e-02*V(F1120) +2.9257127597811784e-02*V(F1121) -5.1139427095185569e-02*V(F1122) +8.2314070811591256e-02*V(F1123) -9.9788210728907464e-02*V(F1124) +9.5283483499124175e-02*V(F1125) -6.5359220226430759e-02*V(F1126) +3.1654578311366449e-02*V(F1127) -1.0470910435865267e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1066)));
	I(F1067)<+( -2.7412433828325651e-27*V(reduced_0) +2.0157555194985832e-27*V(reduced_1) +1.6813624312304346e-01*V(F841) +2.9125925823092919e-01*V(F850) -4.1341855488035417e-01*V(F859) +5.1275837742189956e-01*V(F868) -4.5950216693134993e-01*V(F877) +2.8053321165745232e-01*V(F886) -1.0731851881103864e-01*V(F895) +1.8481154365692865e-02*V(F904) -6.5624914641177496e-03*V(F913) +4.8655123218321772e-01*V(F1001) +8.4466575175432312e-01*V(F1009) -1.1987357426199854e+00*V(F1017) +1.4868015713489593e+00*V(F1025) -1.3324279958859593e+00*V(F1033) +8.1352507506729721e-01*V(F1041) -3.1126900103591287e-01*V(F1049) +5.3646381170449009e-02*V(F1057) -1.9027648214159337e-02*V(F1065) -2.1357119500361557e+00*V(F1066) +4.2763350081726053e+00*V(F1067) -5.5830920323097590e+00*V(F1068) +5.4604667984684436e+00*V(F1069) -4.0084603279505533e+00*V(F1070) +2.1557773721474249e+00*V(F1071) -8.2139940275360257e-01*V(F1072) -3.6484455267880338e+00*V(F1073) +7.2982322476688832e+00*V(F1074) -9.5514598044323940e+00*V(F1075) +9.3408078200072033e+00*V(F1076) -6.8571421606307581e+00*V(F1077) +3.6874302301382236e+00*V(F1078) -1.4030239693801345e+00*V(F1079) +5.1842269825255363e+00*V(F1080) -1.0371135583150469e+01*V(F1081) +1.3570540338283999e+01*V(F1082) -1.3271345105483867e+01*V(F1083) +9.7425538706531665e+00*V(F1084) -5.2391038509046561e+00*V(F1085) +1.9936340981800980e+00*V(F1086) -6.4292883031752988e+00*V(F1087) +1.2861811619261088e+01*V(F1088) -1.6829864738761803e+01*V(F1089) +1.6458798722039887e+01*V(F1090) -1.2082480053520174e+01*V(F1091) +6.4974051064730727e+00*V(F1092) -2.4724296791291969e+00*V(F1093) +5.7601541176984128e+00*V(F1094) -1.1523014944402213e+01*V(F1095) +1.5078657112997606e+01*V(F1096) -1.4746178309883586e+01*V(F1097) +1.0825242181595975e+01*V(F1098) -5.8213095598634581e+00*V(F1099) +2.2151044657877783e+00*V(F1100) -3.5150593884011574e+00*V(F1101) +7.0315467697366909e+00*V(F1102) -9.2019944042536945e+00*V(F1103) +8.9990663594734368e+00*V(F1104) -6.6062644258222605e+00*V(F1105) +3.5525281151599395e+00*V(F1106) -1.3517332012141370e+00*V(F1107) +1.3431914359853168e+00*V(F1108) -2.6867190594698549e+00*V(F1109) +3.5167218067351516e+00*V(F1110) -3.4391431676431634e+00*V(F1111) +2.5246991424807530e+00*V(F1112) -1.3576490566389126e+00*V(F1113) +5.1652557488835982e-01*V(F1114) -2.3009393378775847e-01*V(F1115) +4.6007573629269638e-01*V(F1116) -6.0276143913464608e-01*V(F1117) +5.8944372383904886e-01*V(F1118) -4.3271891270521079e-01*V(F1119) +2.3268391800250154e-01*V(F1120) -8.8478608015713417e-02*V(F1121) +8.2314070811703388e-02*V(F1122) -1.6467366024236632e-01*V(F1123) +2.1546442477618866e-01*V(F1124) -2.1071435392595231e-01*V(F1125) +1.5468627910113769e-01*V(F1126) -8.3183430654810181e-02*V(F1127) +3.1654578311910687e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1067)));
	I(F1068)<+( +3.1273964829709665e-26*V(reduced_0) -2.3105673017597322e-26*V(reduced_1) -3.7568152510171099e-01*V(F841) -6.5150779994426322e-01*V(F850) +9.2468337545185941e-01*V(F859) -1.1468835379769915e+00*V(F868) +1.0277850648224338e+00*V(F877) -6.2750135953258945e-01*V(F886) +2.4007300961500921e-01*V(F895) -4.1359721804200854e-02*V(F904) +1.4677870163360054e-02*V(F913) -6.1403691502099211e-01*V(F1001) -1.0658251080255383e+00*V(F1009) +1.5126187018937127e+00*V(F1017) -1.8761111110733473e+00*V(F1025) +1.6813115340680522e+00*V(F1033) -1.0265338666637096e+00*V(F1041) +3.9276525498454778e-01*V(F1049) -6.7688275658198779e-02*V(F1057) +2.4010008153534254e-02*V(F1065) +2.5903544832044378e+00*V(F1066) -5.5830920323097590e+00*V(F1067) +8.2005153858161712e+00*V(F1068) -8.6543311962773579e+00*V(F1069) +6.7642536950228571e+00*V(F1070) -4.0084603279975806e+00*V(F1071) +1.6962796511903764e+00*V(F1072) +4.4227315642106317e+00*V(F1073) -9.5514598044332875e+00*V(F1074) +1.4016082803313179e+01*V(F1075) -1.4810096935730265e+01*V(F1076) +1.1574072661879253e+01*V(F1077) -6.8571421607122103e+00*V(F1078) +2.8968612734330601e+00*V(F1079) -6.2847041650764028e+00*V(F1080) +1.3570540338285202e+01*V(F1081) -1.9915248646621187e+01*V(F1082) +2.1041431267805319e+01*V(F1083) -1.6444022901453504e+01*V(F1084) +9.7425538707687913e+00*V(F1085) -4.1163689601593587e+00*V(F1086) +7.7940291484037738e+00*V(F1087) -1.6829864738763305e+01*V(F1088) +2.4698252887265159e+01*V(F1089) -2.6095144505470635e+01*V(F1090) +2.0393514600794362e+01*V(F1091) -1.2082480053663568e+01*V(F1092) +5.1049583448913909e+00*V(F1093) -6.9827935374364998e+00*V(F1094) +1.5078657112998968e+01*V(F1095) -2.2127952399164208e+01*V(F1096) +2.3379971184218451e+01*V(F1097) -1.8271548080385735e+01*V(F1098) +1.0825242181724475e+01*V(F1099) -4.5736305630970131e+00*V(F1100) +4.2610836446537252e+00*V(F1101) -9.2019944042545614e+00*V(F1102) +1.3503521782523947e+01*V(F1103) -1.4268145479518031e+01*V(F1104) +1.1150568036017779e+01*V(F1105) -6.6062644259007124e+00*V(F1106) +2.7909701919751631e+00*V(F1107) -1.6281950360283468e+00*V(F1108) +3.5167218067355202e+00*V(F1109) -5.1602421003386638e+00*V(F1110) +5.4529813110365772e+00*V(F1111) -4.2614636906987009e+00*V(F1112) +2.5246991425107623e+00*V(F1113) -1.0664722264027280e+00*V(F1114) +2.7885881365951937e-01*V(F1115) -6.0276143913476365e-01*V(F1116) +8.8414077442044170e-01*V(F1117) -9.3473983805965011e-01*V(F1118) +7.3045492061518202e-01*V(F1119) -4.3271891271038543e-01*V(F1120) +1.8266917629771534e-01*V(F1121) -9.9788210729050877e-02*V(F1122) +2.1546442477622252e-01*V(F1123) -3.1620718362214578e-01*V(F1124) +3.3408064986594260e-01*V(F1125) -2.6108696465004494e-01*V(F1126) +1.5468627910298155e-01*V(F1127) -6.5359220228198456e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1068)));
	I(F1069)<+( -1.3644015694705547e-26*V(reduced_0) +1.0126957922110933e-26*V(reduced_1) +5.7261308640107844e-01*V(F841) +9.9359234049848200e-01*V(F850) -1.4101417979999586e+00*V(F859) +1.7490041311119695e+00*V(F868) -1.5673934159665786e+00*V(F877) +9.5697020405630095e-01*V(F886) -3.6613961521966482e-01*V(F895) +6.3091844915748749e-02*V(F904) -2.2383513851059144e-02*V(F913) +5.7261308637392794e-01*V(F1001) +9.9359234045335487e-01*V(F1009) -1.4101417979356905e+00*V(F1017) +1.7490041310322657e+00*V(F1025) -1.5673934158951992e+00*V(F1033) +9.5697020401279265e-01*V(F1041) -3.6613961520310495e-01*V(F1049) +6.3091844913033629e-02*V(F1057) -2.2383513850097334e-02*V(F1065) -2.4732690172401854e+00*V(F1066) +5.4604667984684436e+00*V(F1067) -8.6543311962773579e+00*V(F1068) +1.0182205907747154e+01*V(F1069) -8.6543311963619320e+00*V(F1070) +5.4604667985780342e+00*V(F1071) -2.4732690173187524e+00*V(F1072) -4.2231038139654702e+00*V(F1073) +9.3408078200079618e+00*V(F1074) -1.4810096935730879e+01*V(F1075) +1.7408969996855422e+01*V(F1076) -1.4810096935876572e+01*V(F1077) +9.3408078201969449e+00*V(F1078) -4.2231038141002744e+00*V(F1079) +6.0010019363140810e+00*V(F1080) -1.3271345105484873e+01*V(F1081) +2.1041431267806164e+01*V(F1082) -2.4735510387218163e+01*V(F1083) +2.1041431268013035e+01*V(F1084) -1.3271345105753207e+01*V(F1085) +6.0010019365055483e+00*V(F1086) -7.4421970545165808e+00*V(F1087) +1.6458798722041141e+01*V(F1088) -2.6095144505471698e+01*V(F1089) +3.0676262008404130e+01*V(F1090) -2.6095144505728246e+01*V(F1091) +1.6458798722373910e+01*V(F1092) -7.4421970547540308e+00*V(F1093) +6.6675892952172360e+00*V(F1094) -1.4746178309884739e+01*V(F1095) +2.3379971184219421e+01*V(F1096) -2.7484000081679916e+01*V(F1097) +2.3379971184449310e+01*V(F1098) -1.4746178310182920e+01*V(F1099) +6.6675892954299893e+00*V(F1100) -4.0687467160301720e+00*V(F1101) +8.9990663594741598e+00*V(F1102) -1.4268145479518639e+01*V(F1103) +1.6772220343662969e+01*V(F1104) -1.4268145479658946e+01*V(F1105) +8.9990663596561724e+00*V(F1106) -4.0687467161600059e+00*V(F1107) +1.5547099078566993e+00*V(F1108) -3.4391431676434729e+00*V(F1109) +5.4529813110368330e+00*V(F1110) -6.4095175504856696e+00*V(F1111) +5.4529813110904746e+00*V(F1112) -3.4391431677130631e+00*V(F1113) +1.5547099079063011e+00*V(F1114) -2.6627991136664492e-01*V(F1115) +5.8944372383915822e-01*V(F1116) -9.3473983805972183e-01*V(F1117) +1.0983285024317493e+00*V(F1118) -9.3473983806892469e-01*V(F1119) +5.8944372385109545e-01*V(F1120) -2.6627991137508533e-01*V(F1121) +9.5283483499257374e-02*V(F1122) -2.1071435392598886e-01*V(F1123) +3.3408064986595815e-01*V(F1124) -3.9273913787332804e-01*V(F1125) +3.3408064986924346e-01*V(F1126) -2.1071435393024227e-01*V(F1127) +9.5283483502263344e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1069)));
	I(F1070)<+( +3.1813078663198153e-26*V(reduced_0) -2.3719239030193078e-26*V(reduced_1) -6.1403691505134650e-01*V(F841) -1.0658251080760321e+00*V(F850) +1.5126187019656172e+00*V(F859) -1.8761111111625248e+00*V(F868) +1.6813115341479128e+00*V(F877) -1.0265338667123909e+00*V(F886) +3.9276525500307857e-01*V(F895) -6.7688275661240249e-02*V(F904) +2.4010008154611885e-02*V(F913) -3.7568152508520375e-01*V(F1001) -6.5150779991686836e-01*V(F1009) +9.2468337541284074e-01*V(F1017) -1.1468835379285998e+00*V(F1025) +1.0277850647790980e+00*V(F1033) -6.2750135950617558e-01*V(F1041) +2.4007300960495787e-01*V(F1049) -4.1359721802556051e-02*V(F1057) +1.4677870162777528e-02*V(F1065) +1.6962796511462628e+00*V(F1066) -4.0084603279505533e+00*V(F1067) +6.7642536950228571e+00*V(F1068) -8.6543311963619320e+00*V(F1069) +8.2005153859621451e+00*V(F1070) -5.5830920324519298e+00*V(F1071) +2.5903544832959571e+00*V(F1072) +2.8968612733574637e+00*V(F1073) -6.8571421606312821e+00*V(F1074) +1.1574072661879677e+01*V(F1075) -1.4810096935877135e+01*V(F1076) +1.4016082803565688e+01*V(F1077) -9.5514598046784798e+00*V(F1078) +4.4227315643677345e+00*V(F1079) -4.1163689600519779e+00*V(F1080) +9.7425538706538610e+00*V(F1081) -1.6444022901454083e+01*V(F1082) +2.1041431268013820e+01*V(F1083) -1.9915248646979673e+01*V(F1084) +1.3570540338633327e+01*V(F1085) -6.2847041652995319e+00*V(F1086) +5.1049583447582156e+00*V(F1087) -1.2082480053521037e+01*V(F1088) +2.0393514600795093e+01*V(F1089) -2.6095144505729234e+01*V(F1090) +2.4698252887709774e+01*V(F1091) -1.6829864739195067e+01*V(F1092) +7.7940291486804982e+00*V(F1093) -4.5736305629776961e+00*V(F1094) +1.0825242181596767e+01*V(F1095) -1.8271548080386395e+01*V(F1096) +2.3379971184450199e+01*V(F1097) -2.2127952399562620e+01*V(F1098) +1.5078657113385852e+01*V(F1099) -6.9827935376844401e+00*V(F1100) +2.7909701919023542e+00*V(F1101) -6.6062644258227632e+00*V(F1102) +1.1150568036018202e+01*V(F1103) -1.4268145479659514e+01*V(F1104) +1.3503521782767161e+01*V(F1105) -9.2019944044907049e+00*V(F1106) +4.2610836448050362e+00*V(F1107) -1.0664722263749147e+00*V(F1108) +2.5246991424809679e+00*V(F1109) -4.2614636906988785e+00*V(F1110) +5.4529813110907090e+00*V(F1111) -5.1602421004316890e+00*V(F1112) +3.5167218068258128e+00*V(F1113) -1.6281950360861608e+00*V(F1114) +1.8266917629299045e-01*V(F1115) -4.3271891270528640e-01*V(F1116) +7.3045492061523387e-01*V(F1117) -9.3473983806898375e-01*V(F1118) +8.8414077443644157e-01*V(F1119) -6.0276143915026059e-01*V(F1120) +2.7885881366936510e-01*V(F1121) -6.5359220226515566e-02*V(F1122) +1.5468627910116312e-01*V(F1123) -2.6108696465005737e-01*V(F1124) +3.3408064986925134e-01*V(F1125) -3.1620718362783679e-01*V(F1126) +2.1546442478174718e-01*V(F1127) -9.9788210732557947e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1070)));
	I(F1071)<+( -2.8365744873488980e-27*V(reduced_0) +2.1242519484198761e-27*V(reduced_1) +4.8655123220772367e-01*V(F841) +8.4466575179510806e-01*V(F850) -1.1987357426780616e+00*V(F859) +1.4868015714209839e+00*V(F868) -1.3324279959504608e+00*V(F877) +8.1352507510661753e-01*V(F886) -3.1126900105088112e-01*V(F895) +5.3646381172907896e-02*V(F904) -1.9027648215030866e-02*V(F913) +1.6813624311674372e-01*V(F1001) +2.9125925822051346e-01*V(F1009) -4.1341855486551482e-01*V(F1017) +5.1275837740349550e-01*V(F1025) -4.5950216691486995e-01*V(F1033) +2.8053321164740880e-01*V(F1041) -1.0731851880721863e-01*V(F1049) +1.8481154365070713e-02*V(F1057) -6.5624914638974562e-03*V(F1065) -8.2139940274012346e-01*V(F1066) +2.1557773721474249e+00*V(F1067) -4.0084603279975806e+00*V(F1068) +5.4604667985780342e+00*V(F1069) -5.5830920324519298e+00*V(F1070) +4.2763350082968321e+00*V(F1071) -2.1357119501122535e+00*V(F1072) -1.4030239693571436e+00*V(F1073) +3.6874302301385242e+00*V(F1074) -6.8571421607125833e+00*V(F1075) +9.3408078201974512e+00*V(F1076) -9.5514598046791530e+00*V(F1077) +7.2982322478838997e+00*V(F1078) -3.6484455269186142e+00*V(F1079) +1.9936340981474296e+00*V(F1080) -5.2391038509050585e+00*V(F1081) +9.7425538707693047e+00*V(F1082) -1.3271345105753911e+01*V(F1083) +1.3570540338634274e+01*V(F1084) -1.0371135583455713e+01*V(F1085) +5.1842269827110012e+00*V(F1086) -2.4724296790886831e+00*V(F1087) +6.4974051064735754e+00*V(F1088) -1.2082480053664218e+01*V(F1089) +1.6458798722374805e+01*V(F1090) -1.6829864739196260e+01*V(F1091) +1.2861811619639660e+01*V(F1092) -6.4292883034053059e+00*V(F1093) +2.2151044657514847e+00*V(F1094) -5.8213095598639200e+00*V(F1095) +1.0825242181725073e+01*V(F1096) -1.4746178310183737e+01*V(F1097) +1.5078657113386935e+01*V(F1098) -1.1523014944741460e+01*V(F1099) +5.7601541179044888e+00*V(F1100) -1.3517332011919940e+00*V(F1101) +3.5525281151602321e+00*V(F1102) -6.6062644259010854e+00*V(F1103) +8.9990663596566947e+00*V(F1104) -9.2019944044913888e+00*V(F1105) +7.0315467699437892e+00*V(F1106) -3.5150593885269181e+00*V(F1107) +5.1652557487990580e-01*V(F1108) -1.3576490566390365e+00*V(F1109) +2.5246991425109182e+00*V(F1110) -3.4391431677132731e+00*V(F1111) +3.5167218068260930e+00*V(F1112) -2.6867190595490658e+00*V(F1113) +1.3431914360333677e+00*V(F1114) -8.8478608014285712e-02*V(F1115) +2.3268391800254093e-01*V(F1116) -4.3271891271042484e-01*V(F1117) +5.8944372385114319e-01*V(F1118) -6.0276143915032365e-01*V(F1119) +4.6007573630632476e-01*V(F1120) -2.3009393379594537e-01*V(F1121) +3.1654578311401636e-02*V(F1122) -8.3183430654821131e-02*V(F1123) +1.5468627910298724e-01*V(F1124) -2.1071435393024557e-01*V(F1125) +2.1546442478175110e-01*V(F1126) -1.6467366024721192e-01*V(F1127) +8.2314070814622733e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1071)));
	I(F1072)<+( +1.8148790912737553e-26*V(reduced_0) -1.3650110145926444e-26*V(reduced_1) -4.0647969643085691e-01*V(F841) -7.0470066545928378e-01*V(F850) +1.0002034477513868e+00*V(F859) -1.2405482245440536e+00*V(F868) +1.1117172853411510e+00*V(F877) -6.7873832731840800e-01*V(F886) +2.5966917120287442e-01*V(F895) -4.4730592032467084e-02*V(F904) +1.5876720008206283e-02*V(F913) -4.8716018197108107e-02*V(F1001) -8.4166396703849428e-02*V(F1009) +1.1949153117061187e-01*V(F1017) -1.4820116388582161e-01*V(F1025) +1.3280266943881650e-01*V(F1033) -8.1071093002738626e-02*V(F1041) +3.1007351448059228e-02*V(F1049) -5.3344260213144656e-03*V(F1057) +1.8968674457655978e-03*V(F1065) +2.7187014590553799e-01*V(F1066) -8.2139940275360257e-01*V(F1067) +1.6962796511903764e+00*V(F1068) -2.4732690173187524e+00*V(F1069) +2.5903544832959571e+00*V(F1070) -2.1357119501122535e+00*V(F1071) +1.3359359026182676e+00*V(F1072) +4.6407211752033783e-01*V(F1073) -1.4030239693803965e+00*V(F1074) +2.8968612734336086e+00*V(F1075) -4.2231038141011261e+00*V(F1076) +4.4227315643686858e+00*V(F1077) -3.6484455269194962e+00*V(F1078) +2.2650310114315975e+00*V(F1079) -6.5945939705622858e-01*V(F1080) +1.9936340981804648e+00*V(F1081) -4.1163689601601368e+00*V(F1082) +6.0010019365067562e+00*V(F1083) -6.2847041653008802e+00*V(F1084) +5.1842269827122491e+00*V(F1085) -3.2203643454978730e+00*V(F1086) +8.1783268484117555e-01*V(F1087) -2.4724296791296601e+00*V(F1088) +5.1049583448923794e+00*V(F1089) -7.4421970547555665e+00*V(F1090) +7.7940291486822089e+00*V(F1091) -6.4292883034068886e+00*V(F1092) +3.9935572666079824e+00*V(F1093) -7.3270606768502122e-01*V(F1094) +2.2151044657882042e+00*V(F1095) -4.5736305630979155e+00*V(F1096) +6.6675892954313891e+00*V(F1097) -6.9827935376860060e+00*V(F1098) +5.7601541179059366e+00*V(F1099) -3.5774577276752870e+00*V(F1100) +4.4711280154492866e-01*V(F1101) -1.3517332012144045e+00*V(F1102) +2.7909701919757310e+00*V(F1103) -4.0687467161608879e+00*V(F1104) +4.2610836448060203e+00*V(F1105) -3.5150593885278263e+00*V(F1106) +2.1825526914081443e+00*V(F1107) -1.7084205755751738e-01*V(F1108) +5.1652557488846917e-01*V(F1109) -1.0664722264029574e+00*V(F1110) +1.5547099079066582e+00*V(F1111) -1.6281950360865585e+00*V(F1112) +1.3431914360337358e+00*V(F1113) -8.3349773502991065e-01*V(F1114) +2.9257127597836760e-02*V(F1115) -8.8478608015737190e-02*V(F1116) +1.8266917629775961e-01*V(F1117) -2.6627991137515172e-01*V(F1118) +2.7885881366943904e-01*V(F1119) -2.3009393379601564e-01*V(F1120) +1.4236836453887611e-01*V(F1121) -1.0470910435873381e-02*V(F1122) +3.1654578311911465e-02*V(F1123) -6.5359220228195167e-02*V(F1124) +9.5283483502256586e-02*V(F1125) -9.9788210732550287e-02*V(F1126) +8.2314070814617279e-02*V(F1127) -5.1139427097136467e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1072)));
	I(F1073)<+( +1.0264369659541024e-25*V(reduced_0) -7.5064845826926119e-26*V(reduced_1) -8.4166396705802310e-02*V(F841) -5.5700564245366435e-01*V(F850) +4.4254745870507262e-01*V(F859) -5.7565653919337700e-01*V(F868) +5.4502753185464337e-01*V(F877) -3.6619554294673839e-01*V(F886) +1.7307966461490940e-01*V(F895) -6.2293090287583647e-02*V(F904) -5.3344260214509363e-03*V(F913) -7.0470066542680654e-01*V(F1001) -4.6518939306641922e+00*V(F1009) +3.6928479849953786e+00*V(F1017) -4.8041279220673125e+00*V(F1025) +4.5484537331134947e+00*V(F1033) -3.0559347097790939e+00*V(F1041) +1.4443079512170169e+00*V(F1049) -5.1989012973015292e-01*V(F1057) -4.4730592031115742e-02*V(F1065) +2.2650310113449983e+00*V(F1066) -3.6484455267880338e+00*V(F1067) +4.4227315642106317e+00*V(F1068) -4.2231038139654702e+00*V(F1069) +2.8968612733574637e+00*V(F1070) -1.4030239693571436e+00*V(F1071) +4.6407211752033783e-01*V(F1072) +1.5198181644705247e+01*V(F1073) -2.4345528273790627e+01*V(F1074) +2.9523881203286745e+01*V(F1075) -2.8189886955793742e+01*V(F1076) +1.9334726426260996e+01*V(F1077) -9.3630295560108721e+00*V(F1078) +3.0984690626754077e+00*V(F1079) -1.2130744297393363e+01*V(F1080) +1.9396291838180780e+01*V(F1081) -2.3525015558535724e+01*V(F1082) +2.2461705846401475e+01*V(F1083) -1.5405309135919479e+01*V(F1084) +7.4598342274050449e+00*V(F1085) -2.4690495132574326e+00*V(F1086) +1.5769701776380343e+01*V(F1087) -2.5220946527448532e+01*V(F1088) +3.0588977274589094e+01*V(F1089) -2.9206446502340199e+01*V(F1090) +2.0031279126749105e+01*V(F1091) -9.6999628052809008e+00*V(F1092) +3.2104161428187221e+00*V(F1093) -1.4931715508053729e+01*V(F1094) +2.3880046023423098e+01*V(F1095) -2.8962738691216828e+01*V(F1096) +2.7653702024374859e+01*V(F1097) -1.8966315694096874e+01*V(F1098) +9.1842575663525086e+00*V(F1099) -3.0397397932148387e+00*V(F1100) +1.0034175411125496e+01*V(F1101) -1.6046351536021380e+01*V(F1102) +1.9461798707225764e+01*V(F1103) -1.8582166851477020e+01*V(F1104) +1.2744576020088397e+01*V(F1105) -6.1714286458856682e+00*V(F1106) +2.0425879859795635e+00*V(F1107) -4.7435981464870016e+00*V(F1108) +7.5851706292479433e+00*V(F1109) -9.1997216681214375e+00*V(F1110) +8.7839071656989312e+00*V(F1111) -6.0244302378955146e+00*V(F1112) +2.9172616596140730e+00*V(F1113) -9.6554763960924472e-01*V(F1114) +1.7060381360558028e+00*V(F1115) -2.7287953076629337e+00*V(F1116) +3.3095684105503986e+00*V(F1117) -3.1599886286379060e+00*V(F1118) +2.1672870188566185e+00*V(F1119) -1.0494914572806997e+00*V(F1120) +3.4734918095456452e-01*V(F1121) +1.4236836453406990e-01*V(F1122) -2.3009393378828985e-01*V(F1123) +2.7885881366012405e-01*V(F1124) -2.6627991136724211e-01*V(F1125) +1.8266917629343482e-01*V(F1126) -8.8478608014532237e-02*V(F1127) +2.9257127597937218e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1073)));
	I(F1074)<+( -1.6319427294847138e-26*V(reduced_0) +1.1992355498545508e-26*V(reduced_1) +2.9125925823109222e-01*V(F841) +1.9237948239280938e+00*V(F850) -1.5274813052145233e+00*V(F859) +1.9870900058323615e+00*V(F868) -1.8813435066294142e+00*V(F877) +1.2640135007612339e+00*V(F886) -5.9740857095662170e-01*V(F895) +2.1503530714114097e-01*V(F904) +1.8481154365792889e-02*V(F913) +8.4466575175262038e-01*V(F1001) +5.5703004214489669e+00*V(F1009) -4.4204326212979685e+00*V(F1017) +5.7509218783162765e+00*V(F1025) -5.4448309999335507e+00*V(F1033) +3.6581291933735405e+00*V(F1041) -1.7288923608737439e+00*V(F1049) +6.2236132981630099e-01*V(F1057) +5.3646381171154209e-02*V(F1065) -3.6484455267862423e+00*V(F1066) +7.2982322476688832e+00*V(F1067) -9.5514598044332875e+00*V(F1068) +9.3408078200079618e+00*V(F1069) -6.8571421606312821e+00*V(F1070) +3.6874302301385242e+00*V(F1071) -1.4030239693803965e+00*V(F1072) -2.4345528273790627e+01*V(F1073) +4.8734509444440235e+01*V(F1074) -6.3667702592646215e+01*V(F1075) +6.2267784782344798e+01*V(F1076) -4.5710307271062476e+01*V(F1077) +2.4582626561891324e+01*V(F1078) -9.3630295561653618e+00*V(F1079) +1.9396291838176481e+01*V(F1080) -3.8836334053320947e+01*V(F1081) +5.0706676264923637e+01*V(F1082) -4.9592866426240342e+01*V(F1083) +3.6405523280122601e+01*V(F1084) -1.9579092490906870e+01*V(F1085) +7.4598342275271570e+00*V(F1086) -2.5220946527443907e+01*V(F1087) +5.0497190279102931e+01*V(F1088) -6.5936880553313856e+01*V(F1089) +6.4488332271877496e+01*V(F1090) -4.7340143398533534e+01*V(F1091) +2.5459704356653937e+01*V(F1092) -9.6999628054399150e+00*V(F1093) +2.3880046023418949e+01*V(F1094) -4.7812625189413424e+01*V(F1095) +6.2430925467431749e+01*V(F1096) -6.1059420125323904e+01*V(F1097) +4.4823014116096118e+01*V(F1098) -2.4105992583579503e+01*V(F1099) +9.1842575665030868e+00*V(F1100) -1.6046351536018612e+01*V(F1101) +3.2128295822842254e+01*V(F1102) -4.1950289688215896e+01*V(F1103) +4.1028746423869528e+01*V(F1104) -3.0118721075444483e+01*V(F1105) +1.6197982285736263e+01*V(F1106) -6.1714286459868308e+00*V(F1107) +7.5851706292464227e+00*V(F1108) -1.5187332807069184e+01*V(F1109) +1.9829732088207980e+01*V(F1110) -1.9394142819945046e+01*V(F1111) +1.4237008488799948e+01*V(F1112) -7.6567357199518007e+00*V(F1113) +2.9172616596618433e+00*V(F1114) -2.7287953076615445e+00*V(F1115) +5.4635019834901728e+00*V(F1116) -7.1342204965405420e+00*V(F1117) +6.9774820693040720e+00*V(F1118) -5.1220911242082963e+00*V(F1119) +2.7546756315444560e+00*V(F1120) -1.0494914572977443e+00*V(F1121) -2.3009393378918266e-01*V(F1122) +4.6007573629494286e-01*V(F1123) -6.0276143913752955e-01*V(F1124) +5.8944372384184540e-01*V(F1125) -4.3271891270726703e-01*V(F1126) +2.3268391800362090e-01*V(F1127) -8.8478608016167096e-02*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1074)));
	I(F1075)<+( +1.8618315404377560e-25*V(reduced_0) -1.3746410503037040e-25*V(reduced_1) -6.5150779994464936e-01*V(F841) -4.2997862141843255e+00*V(F850) +3.4130723983447675e+00*V(F859) -4.4402054812428853e+00*V(F868) +4.2038941220909445e+00*V(F877) -2.8244297484496665e+00*V(F886) +1.3348884109763026e+00*V(F895) -4.8050943508808669e-01*V(F904) -4.1359721804428103e-02*V(F913) -1.0658251080234016e+00*V(F1001) -7.0295422306775626e+00*V(F1009) +5.5786508659900482e+00*V(F1017) -7.2577119258504919e+00*V(F1025) +6.8714266222319109e+00*V(F1033) -4.6165991725201341e+00*V(F1041) +2.1818848875605457e+00*V(F1049) -7.8542363452001707e-01*V(F1057) -6.7688275659088984e-02*V(F1065) +4.4227315642084992e+00*V(F1066) -9.5514598044323940e+00*V(F1067) +1.4016082803313179e+01*V(F1068) -1.4810096935730879e+01*V(F1069) +1.1574072661879677e+01*V(F1070) -6.8571421607125833e+00*V(F1071) +2.8968612734336086e+00*V(F1072) +2.9523881203286745e+01*V(F1073) -6.3667702592646215e+01*V(F1074) +9.3492415025759868e+01*V(F1075) -9.8698925245463585e+01*V(F1076) +7.7140652772968295e+01*V(F1077) -4.5710307271601017e+01*V(F1078) +1.9334726426766451e+01*V(F1079) -2.3525015558530328e+01*V(F1080) +5.0706676264922066e+01*V(F1081) -7.4477002499071119e+01*V(F1082) +7.8600772647281644e+01*V(F1083) -6.1434435094737204e+01*V(F1084) +3.6405523280550156e+01*V(F1085) -1.5405309136319474e+01*V(F1086) +3.0588977274583357e+01*V(F1087) -6.5936880553312093e+01*V(F1088) +9.6843852485384303e+01*V(F1089) -1.0221021480354112e+02*V(F1090) +7.9887247058078486e+01*V(F1091) -4.7340143399089783e+01*V(F1092) +2.0031279127269872e+01*V(F1093) -2.8962738691211687e+01*V(F1094) +6.2430925467430136e+01*V(F1095) -9.1694860808716498e+01*V(F1096) +9.6775446301070943e+01*V(F1097) -7.5639484265622428e+01*V(F1098) +4.4823014116622787e+01*V(F1099) -1.8966315694590005e+01*V(F1100) +1.9461798707222314e+01*V(F1101) -4.1950289688214852e+01*V(F1102) +6.1614660134038473e+01*V(F1103) -6.5027813287305776e+01*V(F1104) +5.0825665691940706e+01*V(F1105) -3.0118721075798337e+01*V(F1106) +1.2744576020419712e+01*V(F1107) -9.1997216681195209e+00*V(F1108) +1.9829732088207457e+01*V(F1109) -2.9125313081077568e+01*V(F1110) +3.0738279683144917e+01*V(F1111) -2.4025041419020965e+01*V(F1112) +1.4237008488967163e+01*V(F1113) -6.0244302380519885e+00*V(F1114) +3.3095684105486081e+00*V(F1115) -7.1342204965401512e+00*V(F1116) +1.0478150367672434e+01*V(F1117) -1.1058957546533962e+01*V(F1118) +8.6436377200575087e+00*V(F1119) -5.1220911242683975e+00*V(F1120) +2.1672870189125537e+00*V(F1121) +2.7885881366128112e-01*V(F1122) -6.0276143913776559e-01*V(F1123) +8.8414077442475947e-01*V(F1124) -9.3473983806420724e-01*V(F1125) +7.3045492061873896e-01*V(F1126) -4.3271891271251123e-01*V(F1127) +1.8266917629867319e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1075)));
	I(F1076)<+( -8.1226879706203867e-26*V(reduced_0) +6.0249525989476499e-26*V(reduced_1) +9.9359234049909329e-01*V(F841) +6.5547312367274131e+00*V(F850) -5.2022669613402828e+00*V(F859) +6.7679694597917273e+00*V(F868) -6.4077585083973023e+00*V(F877) +4.3050953675420534e+00*V(F886) -2.0346705990237055e+00*V(F895) +7.3242075299762133e-01*V(F904) +6.3091844916097650e-02*V(F913) +9.9359234045140565e-01*V(F1001) +6.5547312364180499e+00*V(F1009) -5.2022669610907180e+00*V(F1017) +6.7679694594679676e+00*V(F1025) -6.4077585080909190e+00*V(F1033) +4.3050953673361931e+00*V(F1041) -2.0346705989262248e+00*V(F1049) +7.3242075296189590e-01*V(F1057) +6.3091844913853320e-02*V(F1065) -4.2231038139635224e+00*V(F1066) +9.3408078200072033e+00*V(F1067) -1.4810096935730265e+01*V(F1068) +1.7408969996855422e+01*V(F1069) -1.4810096935877135e+01*V(F1070) +9.3408078201974512e+00*V(F1071) -4.2231038141011261e+00*V(F1072) -2.8189886955793742e+01*V(F1073) +6.2267784782344798e+01*V(F1074) -9.8698925245463585e+01*V(F1075) +1.1609564782366617e+02*V(F1076) -9.8698925246431926e+01*V(F1077) +6.2267784783599701e+01*V(F1078) -2.8189886956693950e+01*V(F1079) +2.2461705846396494e+01*V(F1080) -4.9592866426238800e+01*V(F1081) +7.8600772647280749e+01*V(F1082) -9.2475402539979939e+01*V(F1083) +7.8600772648050949e+01*V(F1084) -4.9592866427236807e+01*V(F1085) +2.2461705847114104e+01*V(F1086) -2.9206446502334902e+01*V(F1087) +6.4488332271875777e+01*V(F1088) -1.0221021480354010e+02*V(F1089) +1.2024883014293786e+02*V(F1090) -1.0221021480454186e+02*V(F1091) +6.4488332273173896e+01*V(F1092) -2.9206446503267923e+01*V(F1093) +2.7653702024370098e+01*V(F1094) -6.1059420125322383e+01*V(F1095) +9.6775446301069962e+01*V(F1096) -1.1385529747777879e+02*V(F1097) +9.6775446302018409e+01*V(F1098) -6.1059420126551373e+01*V(F1099) +2.7653702025253331e+01*V(F1100) -1.8582166851473858e+01*V(F1101) +4.1028746423868498e+01*V(F1102) -6.5027813287305165e+01*V(F1103) +7.6505195138634420e+01*V(F1104) -6.5027813287942365e+01*V(F1105) +4.1028746424694241e+01*V(F1106) -1.8582166852067228e+01*V(F1107) +8.7839071656971566e+00*V(F1108) -1.9394142819944506e+01*V(F1109) +3.0738279683144626e+01*V(F1110) -3.6163946142880498e+01*V(F1111) +3.0738279683445793e+01*V(F1112) -1.9394142820334796e+01*V(F1113) +8.7839071659777002e+00*V(F1114) -3.1599886286362397e+00*V(F1115) +6.9774820693036324e+00*V(F1116) -1.1058957546533799e+01*V(F1117) +1.3010542554518688e+01*V(F1118) -1.1058957546642217e+01*V(F1119) +6.9774820694442061e+00*V(F1120) -3.1599886287376364e+00*V(F1121) -2.6627991136831997e-01*V(F1122) +5.8944372384211996e-01*V(F1123) -9.3473983806429495e-01*V(F1124) +1.0983285024371141e+00*V(F1125) -9.3473983807351113e-01*V(F1126) +5.8944372385400967e-01*V(F1127) -2.6627991137649504e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1076)));
	I(F1077)<+( +1.8939276198268216e-25*V(reduced_0) -1.4111696315186954e-25*V(reduced_1) -1.0658251080767036e+00*V(F841) -7.0295422310234601e+00*V(F850) +5.5786508662689984e+00*V(F859) -7.2577119262123926e+00*V(F868) +6.8714266225743934e+00*V(F877) -4.6165991727502504e+00*V(F886) +2.1818848876695065e+00*V(F895) -7.8542363455993447e-01*V(F904) -6.7688275661616171e-02*V(F913) -6.5150779991563867e-01*V(F1001) -4.2997862139962715e+00*V(F1009) +3.4130723981929760e+00*V(F1017) -4.4402054810459823e+00*V(F1025) +4.2038941219046162e+00*V(F1033) -2.8244297483244698e+00*V(F1041) +1.3348884109170152e+00*V(F1049) -4.8050943506634347e-01*V(F1057) -4.1359721803080562e-02*V(F1065) +2.8968612733562220e+00*V(F1066) -6.8571421606307581e+00*V(F1067) +1.1574072661879253e+01*V(F1068) -1.4810096935876572e+01*V(F1069) +1.4016082803565688e+01*V(F1070) -9.5514598046791530e+00*V(F1071) +4.4227315643686858e+00*V(F1072) +1.9334726426260996e+01*V(F1073) -4.5710307271062476e+01*V(F1074) +7.7140652772968295e+01*V(F1075) -9.8698925246431926e+01*V(F1076) +9.3492415027431349e+01*V(F1077) -6.3667702594274111e+01*V(F1078) +2.9523881204335307e+01*V(F1079) -1.5405309135916323e+01*V(F1080) +3.6405523280121557e+01*V(F1081) -6.1434435094736578e+01*V(F1082) +7.8600772648050338e+01*V(F1083) -7.4477002500399266e+01*V(F1084) +5.0706676266216469e+01*V(F1085) -2.3525015559365993e+01*V(F1086) +2.0031279126745730e+01*V(F1087) -4.7340143398532376e+01*V(F1088) +7.9887247058077762e+01*V(F1089) -1.0221021480454110e+02*V(F1090) +9.6843852487111803e+01*V(F1091) -6.5936880554995710e+01*V(F1092) +3.0588977275669883e+01*V(F1093) -1.8966315694093858e+01*V(F1094) +4.4823014116095081e+01*V(F1095) -7.5639484265621746e+01*V(F1096) +9.6775446302017656e+01*V(F1097) -9.1694860810352083e+01*V(F1098) +6.2430925469024146e+01*V(F1099) -2.8962738692240261e+01*V(F1100) +1.2744576020086379e+01*V(F1101) -3.0118721075443791e+01*V(F1102) +5.0825665691940280e+01*V(F1103) -6.5027813287941910e+01*V(F1104) +6.1614660135137434e+01*V(F1105) -4.1950289689285803e+01*V(F1106) +1.9461798707913339e+01*V(F1107) -6.0244302378943866e+00*V(F1108) +1.4237008488799576e+01*V(F1109) -2.4025041419020756e+01*V(F1110) +3.0738279683445594e+01*V(F1111) -2.9125313081597007e+01*V(F1112) +1.9829732088713637e+01*V(F1113) -9.1997216684462266e+00*V(F1114) +2.1672870188555571e+00*V(F1115) -5.1220911242079934e+00*V(F1116) +8.6436377200573720e+00*V(F1117) -1.1058957546642159e+01*V(F1118) +1.0478150367859381e+01*V(F1119) -7.1342204967224108e+00*V(F1120) +3.3095684106666425e+00*V(F1121) +1.8266917629412113e-01*V(F1122) -4.3271891270745771e-01*V(F1123) +7.3045492061881589e-01*V(F1124) -9.3473983807353167e-01*V(F1125) +8.8414077444076200e-01*V(F1126) -6.0276143915325175e-01*V(F1127) +2.7885881367084919e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1077)));
	I(F1078)<+( -1.6886979917083649e-26*V(reduced_0) +1.2638287726542455e-26*V(reduced_1) +8.4466575179564762e-01*V(F841) +5.5703004217282368e+00*V(F850) -4.4204326215231298e+00*V(F859) +5.7509218786084135e+00*V(F868) -5.4448310002100095e+00*V(F877) +3.6581291935592932e+00*V(F886) -1.7288923609616955e+00*V(F895) +6.2236132984851023e-01*V(F904) +5.3646381173207150e-02*V(F913) +2.9125925822000437e-01*V(F1001) +1.9237948238563554e+00*V(F1009) -1.5274813051565392e+00*V(F1017) +1.9870900057571643e+00*V(F1025) -1.8813435065582576e+00*V(F1033) +1.2640135007134221e+00*V(F1041) -5.9740857093397604e-01*V(F1049) +2.1503530713282298e-01*V(F1057) +1.8481154365293819e-02*V(F1065) -1.4030239693566107e+00*V(F1066) +3.6874302301382236e+00*V(F1067) -6.8571421607122103e+00*V(F1068) +9.3408078201969449e+00*V(F1069) -9.5514598046784798e+00*V(F1070) +7.2982322478838997e+00*V(F1071) -3.6484455269194962e+00*V(F1072) -9.3630295560108721e+00*V(F1073) +2.4582626561891324e+01*V(F1074) -4.5710307271601017e+01*V(F1075) +6.2267784783599701e+01*V(F1076) -6.3667702594274111e+01*V(F1077) +4.8734509445862798e+01*V(F1078) -2.4345528274662495e+01*V(F1079) +7.4598342274037197e+00*V(F1080) -1.9579092490906362e+01*V(F1081) +3.6405523280549716e+01*V(F1082) -4.9592866427236345e+01*V(F1083) +5.0706676266215872e+01*V(F1084) -3.8836334054451036e+01*V(F1085) +1.9396291838871260e+01*V(F1086) -9.6999628052794868e+00*V(F1087) +2.5459704356653354e+01*V(F1088) -4.7340143399089278e+01*V(F1089) +6.4488332273173313e+01*V(F1090) -6.5936880554994900e+01*V(F1091) +5.0497190280572944e+01*V(F1092) -2.5220946528347305e+01*V(F1093) +9.1842575663512385e+00*V(F1094) -2.4105992583578971e+01*V(F1095) +4.4823014116622304e+01*V(F1096) -6.1059420126550791e+01*V(F1097) +6.2430925469023386e+01*V(F1098) -4.7812625190805235e+01*V(F1099) +2.3880046024274176e+01*V(F1100) -6.1714286458848155e+00*V(F1101) +1.6197982285735904e+01*V(F1102) -3.0118721075798028e+01*V(F1103) +4.1028746424693871e+01*V(F1104) -4.1950289689285327e+01*V(F1105) +3.2128295823777385e+01*V(F1106) -1.6046351536593182e+01*V(F1107) +2.9172616596136001e+00*V(F1108) -7.6567357199516284e+00*V(F1109) +1.4237008488967026e+01*V(F1110) -1.9394142820334650e+01*V(F1111) +1.9829732088713456e+01*V(F1112) -1.5187332807511167e+01*V(F1113) +7.5851706295180454e+00*V(F1114) -1.0494914572802614e+00*V(F1115) +2.7546756315443295e+00*V(F1116) -5.1220911242683496e+00*V(F1117) +6.9774820694442026e+00*V(F1118) -7.1342204967224117e+00*V(F1119) +5.4635019836492553e+00*V(F1120) -2.7287953077596390e+00*V(F1121) -8.8478608014815149e-02*V(F1122) +2.3268391800369606e-01*V(F1123) -4.3271891271252944e-01*V(F1124) +5.8944372385399180e-01*V(F1125) -6.0276143915322422e-01*V(F1126) +4.6007573630857362e-01*V(F1127) -2.3009393379717413e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1078)));
	I(F1079)<+( +1.0804523190700742e-25*V(reduced_0) -8.1212338762941360e-26*V(reduced_1) -7.0470066545969290e-01*V(F841) -4.6518939308777263e+00*V(F850) +3.6928479851674023e+00*V(F859) -4.8041279222905420e+00*V(F868) +4.5484537333247550e+00*V(F877) -3.0559347099210421e+00*V(F886) +1.4443079512842179e+00*V(F895) -5.1989012975473115e-01*V(F904) -4.4730592032718029e-02*V(F913) -8.4166396703720711e-02*V(F1001) -5.5700564244033668e-01*V(F1009) +4.4254745869422490e-01*V(F1017) -5.7565653917932524e-01*V(F1025) +5.4502753184134967e-01*V(F1033) -3.6619554293780587e-01*V(F1041) +1.7307966461067537e-01*V(F1049) -6.2293090286016317e-02*V(F1057) -5.3344260213721729e-03*V(F1065) +4.6407211752016236e-01*V(F1066) -1.4030239693801345e+00*V(F1067) +2.8968612734330601e+00*V(F1068) -4.2231038141002744e+00*V(F1069) +4.4227315643677345e+00*V(F1070) -3.6484455269186142e+00*V(F1071) +2.2650310114315975e+00*V(F1072) +3.0984690626754077e+00*V(F1073) -9.3630295561653618e+00*V(F1074) +1.9334726426766451e+01*V(F1075) -2.8189886956693950e+01*V(F1076) +2.9523881204335307e+01*V(F1077) -2.4345528274662495e+01*V(F1078) +1.5198181645276154e+01*V(F1079) -2.4690495132570884e+00*V(F1080) +7.4598342275269447e+00*V(F1081) -1.5405309136319158e+01*V(F1082) +2.2461705847113663e+01*V(F1083) -2.3525015559365503e+01*V(F1084) +1.9396291838870759e+01*V(F1085) -1.2130744297846356e+01*V(F1086) +3.2104161428183402e+00*V(F1087) -9.6999628054396201e+00*V(F1088) +2.0031279127269368e+01*V(F1089) -2.9206446503267205e+01*V(F1090) +3.0588977275669070e+01*V(F1091) -2.5220946528346509e+01*V(F1092) +1.5769701776969693e+01*V(F1093) -3.0397397932144927e+00*V(F1094) +9.1842575665028114e+00*V(F1095) -1.8966315694589532e+01*V(F1096) +2.7653702025252624e+01*V(F1097) -2.8962738692239476e+01*V(F1098) +2.3880046024273405e+01*V(F1099) -1.4931715508611713e+01*V(F1100) +2.0425879859793348e+00*V(F1101) -6.1714286459866559e+00*V(F1102) +1.2744576020419421e+01*V(F1103) -1.8582166852066820e+01*V(F1104) +1.9461798707912855e+01*V(F1105) -1.6046351536592717e+01*V(F1106) +1.0034175411500382e+01*V(F1107) -9.6554763960912460e-01*V(F1108) +2.9172616596617806e+00*V(F1109) -6.0244302380519050e+00*V(F1110) +8.7839071659775900e+00*V(F1111) -9.1997216684461023e+00*V(F1112) +7.5851706295179131e+00*V(F1113) -4.7435981466641781e+00*V(F1114) +3.4734918095446754e-01*V(F1115) -1.0494914572977536e+00*V(F1116) +2.1672870189126425e+00*V(F1117) -3.1599886287377958e+00*V(F1118) +3.3095684106668215e+00*V(F1119) -2.7287953077597829e+00*V(F1120) +1.7060381361195855e+00*V(F1121) +2.9257127597997402e-02*V(F1122) -8.8478608016149388e-02*V(F1123) +1.8266917629858923e-01*V(F1124) -2.6627991137634882e-01*V(F1125) +2.7885881367068499e-01*V(F1126) -2.3009393379703788e-01*V(F1127) +1.4236836453957313e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1079)));
	I(F1080)<+( -1.6177005827533626e-26*V(reduced_0) +1.1822450892442116e-26*V(reduced_1) +1.1949153117339588e-01*V(F841) +4.4254745870500395e-01*V(F850) -1.0012390694146167e+00*V(F859) +9.3082249721018329e-01*V(F868) -9.2453612386405026e-01*V(F877) +6.7588006180513072e-01*V(F886) -3.6982558640322927e-01*V(F895) +1.7307966461493970e-01*V(F904) +3.1007351448848849e-02*V(F913) +1.0002034477053401e+00*V(F1001) +3.6928479849990707e+00*V(F1009) -8.3564854181089103e+00*V(F1017) +7.7640863123501447e+00*V(F1025) -7.7118989013754433e+00*V(F1033) +5.6377179625022746e+00*V(F1041) -3.0849355749825906e+00*V(F1049) +1.4443079512155130e+00*V(F1057) +2.5966917119370470e-01*V(F1065) -3.2203643453749811e+00*V(F1066) +5.1842269825255363e+00*V(F1067) -6.2847041650764028e+00*V(F1068) +6.0010019363140810e+00*V(F1069) -4.1163689600519779e+00*V(F1070) +1.9936340981474296e+00*V(F1071) -6.5945939705622858e-01*V(F1072) -1.2130744297393363e+01*V(F1073) +1.9396291838176481e+01*V(F1074) -2.3525015558530328e+01*V(F1075) +2.2461705846396494e+01*V(F1076) -1.5405309135916323e+01*V(F1077) +7.4598342274037197e+00*V(F1078) -2.4690495132570884e+00*V(F1079) +2.7416374785764653e+01*V(F1080) -4.3855372301811947e+01*V(F1081) +5.3188901234996507e+01*V(F1082) -5.0784998895395368e+01*V(F1083) +3.4831085584290584e+01*V(F1084) -1.6866704679564048e+01*V(F1085) +5.5823226077222516e+00*V(F1086) -2.5571411588427427e+01*V(F1087) +4.0851083021687217e+01*V(F1088) -4.9549830407552854e+01*V(F1089) +4.7309852068039788e+01*V(F1090) -3.2446741709980216e+01*V(F1091) +1.5711600394473352e+01*V(F1092) -5.2006141185251442e+00*V(F1093) +2.5394317348254027e+01*V(F1094) -4.0570964506023479e+01*V(F1095) +4.9209821125391962e+01*V(F1096) -4.6985242219026063e+01*V(F1097) +3.2224160494689563e+01*V(F1098) -1.5603846984585843e+01*V(F1099) +5.1649159703409842e+00*V(F1100) -1.8565318031051607e+01*V(F1101) +2.9660139087446698e+01*V(F1102) -3.5975779308209873e+01*V(F1103) +3.4349452799046773e+01*V(F1104) -2.3558074648239465e+01*V(F1105) +1.1407478719371126e+01*V(F1106) -3.7759127236856598e+00*V(F1107) +1.0156558784839156e+01*V(F1108) -1.6227456807726323e+01*V(F1109) +1.9682720187373441e+01*V(F1110) -1.8792952895934842e+01*V(F1111) +1.2888895539256813e+01*V(F1112) -6.2411754767667231e+00*V(F1113) +2.0658356462305494e+00*V(F1114) -4.7435981464877930e+00*V(F1115) +7.5851706292508068e+00*V(F1116) -9.1997216681250791e+00*V(F1117) +8.7839071657023666e+00*V(F1118) -6.0244302378977688e+00*V(F1119) +2.9172616596150687e+00*V(F1120) -9.6554763960950096e-01*V(F1121) -8.3349773500050761e-01*V(F1122) +1.3431914359872266e+00*V(F1123) -1.6281950360305217e+00*V(F1124) +1.5547099078588487e+00*V(F1125) -1.0664722263765165e+00*V(F1126) +5.1652557488079542e-01*V(F1127) -1.7084205755787985e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1080)));
	I(F1081)<+( +2.5719995954719470e-27*V(reduced_0) -1.8887721987793397e-27*V(reduced_1) -4.1341855488058321e-01*V(F841) -1.5274813052143708e+00*V(F850) +3.4563568245082132e+00*V(F859) -3.2117827965421846e+00*V(F868) +3.1901705362290755e+00*V(F877) -2.3321516331464616e+00*V(F886) +1.2761330440494461e+00*V(F895) -5.9740857095667255e-01*V(F904) -1.0731851881141136e-01*V(F913) -1.1987357426178247e+00*V(F1001) -4.4204326213030507e+00*V(F1009) +1.0003691344639142e+01*V(F1017) -9.2923028789096289e+00*V(F1025) +9.2299605507133755e+00*V(F1033) -6.7474610839890410e+00*V(F1041) +3.6922341833740089e+00*V(F1049) -1.7288923608716089e+00*V(F1057) -3.1126900103895039e-01*V(F1065) +5.1842269825232012e+00*V(F1066) -1.0371135583150469e+01*V(F1067) +1.3570540338285202e+01*V(F1068) -1.3271345105484873e+01*V(F1069) +9.7425538706538610e+00*V(F1070) -5.2391038509050585e+00*V(F1071) +1.9936340981804648e+00*V(F1072) +1.9396291838180780e+01*V(F1073) -3.8836334053320947e+01*V(F1074) +5.0706676264922066e+01*V(F1075) -4.9592866426238800e+01*V(F1076) +3.6405523280121557e+01*V(F1077) -1.9579092490906362e+01*V(F1078) +7.4598342275269447e+00*V(F1079) -4.3855372301811947e+01*V(F1080) +8.7804955699050865e+01*V(F1081) -1.1465797429751589e+02*V(F1082) +1.1213884753937501e+02*V(F1083) -8.2319886302684978e+01*V(F1084) +4.4271832741637070e+01*V(F1085) -1.6866704679841600e+01*V(F1086) +4.0851083021683060e+01*V(F1087) -8.1803557358849915e+01*V(F1088) +1.0677661740730066e+02*V(F1089) -1.0443232680986769e+02*V(F1090) +7.6662281982455340e+01*V(F1091) -4.1229909416392005e+01*V(F1092) +1.5711600394730592e+01*V(F1093) -4.0570964506020381e+01*V(F1094) +8.1241906246921189e+01*V(F1095) -1.0604585477500576e+02*V(F1096) +1.0371751972720590e+02*V(F1097) -7.6137569845285284e+01*V(F1098) +4.0947673289697136e+01*V(F1099) -1.5603846984841544e+01*V(F1100) +2.9660139087444140e+01*V(F1101) -5.9393508862396310e+01*V(F1102) +7.7526468645317223e+01*V(F1103) -7.5824320440486488e+01*V(F1104) +5.5661561835310891e+01*V(F1105) -2.9935445037448698e+01*V(F1106) +1.1407478719558013e+01*V(F1107) -1.6227456807723705e+01*V(F1108) +3.2494661156187064e+01*V(F1109) -4.2416387033302847e+01*V(F1110) +4.1485066286325704e+01*V(F1111) -3.0453608518820204e+01*V(F1112) +1.6378292674056130e+01*V(F1113) -6.2411754768687713e+00*V(F1114) +7.5851706292459680e+00*V(F1115) -1.5187332807071598e+01*V(F1116) +1.9829732088211451e+01*V(F1117) -1.9394142819948549e+01*V(F1118) +1.4237008488802505e+01*V(F1119) -7.6567357199531267e+00*V(F1120) +2.9172616596622216e+00*V(F1121) +1.3431914359908044e+00*V(F1122) -2.6867190594779915e+00*V(F1123) +3.5167218067455410e+00*V(F1124) -3.4391431676532109e+00*V(F1125) +2.5246991424881475e+00*V(F1126) -1.3576490566429493e+00*V(F1127) +5.1652557489002315e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1081)));
	I(F1082)<+( -2.9343133378588052e-26*V(reduced_0) +2.1650525968724791e-26*V(reduced_1) +9.2468337545240242e-01*V(F841) +3.4130723983444207e+00*V(F850) -7.7235200097962080e+00*V(F859) +7.1756042116900662e+00*V(F868) -7.1273928868905516e+00*V(F877) +5.2104158117224495e+00*V(F886) -2.8511267090999906e+00*V(F895) +1.3348884109764001e+00*V(F904) +2.4007300961585923e-01*V(F913) +1.5126187018910031e+00*V(F1001) +5.5786508659964511e+00*V(F1009) -1.2624699053058087e+01*V(F1017) +1.1727231375262003e+01*V(F1025) -1.1648536786165826e+01*V(F1033) +8.5155378013695131e+00*V(F1041) -4.6597247262427839e+00*V(F1049) +2.1818848875578509e+00*V(F1057) +3.9276525498838244e-01*V(F1065) -6.2847041650736379e+00*V(F1066) +1.3570540338283999e+01*V(F1067) -1.9915248646621187e+01*V(F1068) +2.1041431267806164e+01*V(F1069) -1.6444022901454083e+01*V(F1070) +9.7425538707693047e+00*V(F1071) -4.1163689601601368e+00*V(F1072) -2.3525015558535724e+01*V(F1073) +5.0706676264923637e+01*V(F1074) -7.4477002499071119e+01*V(F1075) +7.8600772647280749e+01*V(F1076) -6.1434435094736578e+01*V(F1077) +3.6405523280549716e+01*V(F1078) -1.5405309136319158e+01*V(F1079) +5.3188901234996507e+01*V(F1080) -1.1465797429751589e+02*V(F1081) +1.6839862081739358e+02*V(F1082) -1.7773507420659669e+02*V(F1083) +1.3891686091944749e+02*V(F1084) -8.2319886303653050e+01*V(F1085) +3.4831085585198892e+01*V(F1086) -4.9549830407547525e+01*V(F1087) +1.0677661740729948e+02*V(F1088) -1.5684881126073464e+02*V(F1089) +1.6550939018402769e+02*V(F1090) -1.2936431981555646e+02*V(F1091) +7.6662281983354831e+01*V(F1092) -3.2446741710822629e+01*V(F1093) +4.9209821125388018e+01*V(F1094) -1.0604585477500481e+02*V(F1095) +1.5577401379083460e+02*V(F1096) -1.6437711965991778e+02*V(F1097) +1.2847916438396393e+02*V(F1098) -7.6137569846178906e+01*V(F1099) +3.2224160495526768e+01*V(F1100) -3.5975779308206604e+01*V(F1101) +7.7526468645316470e+01*V(F1102) -1.1388127499457988e+02*V(F1103) +1.2017035752889944e+02*V(F1104) -9.3926650033439856e+01*V(F1105) +5.5661561835964065e+01*V(F1106) -2.3558074648851342e+01*V(F1107) +1.9682720187370059e+01*V(F1108) -4.2416387033302136e+01*V(F1109) +6.2306281719482058e+01*V(F1110) -6.5747968637489961e+01*V(F1111) +5.1389362372403625e+01*V(F1112) -3.0453608519177525e+01*V(F1113) +1.2888895539591104e+01*V(F1114) -9.1997216681187979e+00*V(F1115) +1.9829732088210193e+01*V(F1116) -2.9125313081082169e+01*V(F1117) +3.0738279683149813e+01*V(F1118) -2.4025041419024856e+01*V(F1119) +1.4237008488969385e+01*V(F1120) -6.0244302380526618e+00*V(F1121) -1.6281950360351649e+00*V(F1122) +3.5167218067464718e+00*V(F1123) -5.1602421003543135e+00*V(F1124) +5.4529813110530885e+00*V(F1125) -4.2614636907115777e+00*V(F1126) +2.5246991425184766e+00*V(F1127) -1.0664722264062618e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1082)));
	I(F1083)<+( +1.2801651348665375e-26*V(reduced_0) -9.4893556881493348e-27*V(reduced_1) -1.4101417980008177e+00*V(F841) -5.2022669613397401e+00*V(F850) +1.1772707128984367e+01*V(F859) -1.0936444836932196e+01*V(F868) +1.0863022981632177e+01*V(F877) -7.9413029657512393e+00*V(F886) +4.3454869750046816e+00*V(F895) -2.0346705990238441e+00*V(F904) -3.6613961522097188e-01*V(F913) -1.4101417979332187e+00*V(F1001) -5.2022669610965639e+00*V(F1009) +1.1772707128427269e+01*V(F1017) -1.0936444836410235e+01*V(F1025) +1.0863022981114572e+01*V(F1033) -7.9413029653726168e+00*V(F1041) +4.3454869747965850e+00*V(F1049) -2.0346705989237690e+00*V(F1057) -3.6613961520663107e-01*V(F1065) +6.0010019363115594e+00*V(F1066) -1.3271345105483867e+01*V(F1067) +2.1041431267805319e+01*V(F1068) -2.4735510387218163e+01*V(F1069) +2.1041431268013820e+01*V(F1070) -1.3271345105753911e+01*V(F1071) +6.0010019365067562e+00*V(F1072) +2.2461705846401475e+01*V(F1073) -4.9592866426240342e+01*V(F1074) +7.8600772647281644e+01*V(F1075) -9.2475402539979939e+01*V(F1076) +7.8600772648050338e+01*V(F1077) -4.9592866427236345e+01*V(F1078) +2.2461705847113663e+01*V(F1079) -5.0784998895395368e+01*V(F1080) +1.1213884753937501e+02*V(F1081) -1.7773507420659669e+02*V(F1082) +2.0909838322216845e+02*V(F1083) -1.7773507420833752e+02*V(F1084) +1.1213884754163081e+02*V(F1085) -5.0784998897012976e+01*V(F1086) +4.7309852068034836e+01*V(F1087) -1.0443232680986637e+02*V(F1088) +1.6550939018402721e+02*V(F1089) -1.9474583981440199e+02*V(F1090) +1.6550939018564591e+02*V(F1091) -1.0443232681196413e+02*V(F1092) +4.7309852069540419e+01*V(F1093) -4.6985242219022375e+01*V(F1094) +1.0371751972720489e+02*V(F1095) -1.6437711965991721e+02*V(F1096) +1.9341195067780347e+02*V(F1097) -1.6437711966152506e+02*V(F1098) +1.0371751972928834e+02*V(F1099) -4.6985242220517328e+01*V(F1100) +3.4349452799043732e+01*V(F1101) -7.5824320440485664e+01*V(F1102) +1.2017035752889905e+02*V(F1103) -1.4139702041250214e+02*V(F1104) +1.2017035753007445e+02*V(F1105) -7.5824320442008826e+01*V(F1106) +3.4349452800136767e+01*V(F1107) -1.8792952895931698e+01*V(F1108) +4.1485066286324887e+01*V(F1109) -6.5747968637489649e+01*V(F1110) +7.7360853099805482e+01*V(F1111) -6.5747968638132861e+01*V(F1112) +4.1485066287158467e+01*V(F1113) -1.8792952896530412e+01*V(F1114) +8.7839071656965100e+00*V(F1115) -1.9394142819947078e+01*V(F1116) +3.0738279683149358e+01*V(F1117) -3.6163946142886211e+01*V(F1118) +3.0738279683450575e+01*V(F1119) -1.9394142820337727e+01*V(F1120) +8.7839071659786310e+00*V(F1121) +1.5547099078631752e+00*V(F1122) -3.4391431676543043e+00*V(F1123) +5.4529813110534260e+00*V(F1124) -6.4095175505051181e+00*V(F1125) +5.4529813111071181e+00*V(F1126) -3.4391431677236604e+00*V(F1127) +1.5547099079115132e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1083)));
	I(F1084)<+( -2.9848995499398019e-26*V(reduced_0) +2.2226248172661362e-26*V(reduced_1) +1.5126187019665611e+00*V(F841) +5.5786508662684042e+00*V(F850) -1.2624699053680958e+01*V(F859) +1.1727231375845491e+01*V(F868) -1.1648536786744467e+01*V(F877) +8.5155378017927799e+00*V(F886) -4.6597247264753916e+00*V(F895) +2.1818848876696468e+00*V(F904) +3.9276525500448822e-01*V(F913) +9.2468337541128265e-01*V(F1001) +3.4130723981966615e+00*V(F1009) -7.7235200094575411e+00*V(F1017) +7.1756042113726624e+00*V(F1025) -7.1273928865758149e+00*V(F1033) +5.2104158114922168e+00*V(F1041) -2.8511267089734305e+00*V(F1049) +1.3348884109154748e+00*V(F1057) +2.4007300960720915e-01*V(F1065) -4.1163689600503712e+00*V(F1066) +9.7425538706531665e+00*V(F1067) -1.6444022901453504e+01*V(F1068) +2.1041431268013035e+01*V(F1069) -1.9915248646979673e+01*V(F1070) +1.3570540338634274e+01*V(F1071) -6.2847041653008802e+00*V(F1072) -1.5405309135919479e+01*V(F1073) +3.6405523280122601e+01*V(F1074) -6.1434435094737204e+01*V(F1075) +7.8600772648050949e+01*V(F1076) -7.4477002500399266e+01*V(F1077) +5.0706676266215872e+01*V(F1078) -2.3525015559365503e+01*V(F1079) +3.4831085584290584e+01*V(F1080) -8.2319886302684978e+01*V(F1081) +1.3891686091944749e+02*V(F1082) -1.7773507420833752e+02*V(F1083) +1.6839862082039826e+02*V(F1084) -1.1465797430044213e+02*V(F1085) +5.3188901236880675e+01*V(F1086) -3.2446741709977054e+01*V(F1087) +7.6662281982454431e+01*V(F1088) -1.2936431981555609e+02*V(F1089) +1.6550939018564571e+02*V(F1090) -1.5684881126352812e+02*V(F1091) +1.0677661741002034e+02*V(F1092) -4.9549830409301030e+01*V(F1093) +3.2224160494687219e+01*V(F1094) -7.6137569845284631e+01*V(F1095) +1.2847916438396359e+02*V(F1096) -1.6437711966152480e+02*V(F1097) +1.5577401379360919e+02*V(F1098) -1.0604585477770723e+02*V(F1099) +4.9209821127129182e+01*V(F1100) -2.3558074648237529e+01*V(F1101) +5.5661561835310316e+01*V(F1102) -9.3926650033439543e+01*V(F1103) +1.2017035753007430e+02*V(F1104) -1.1388127499660828e+02*V(F1105) +7.7526468647292134e+01*V(F1106) -3.5975779309479627e+01*V(F1107) +1.2888895539254804e+01*V(F1108) -3.0453608518819649e+01*V(F1109) +5.1389362372403397e+01*V(F1110) -6.5747968638132761e+01*V(F1111) +6.2306281720591919e+01*V(F1112) -4.2416387034383291e+01*V(F1113) +1.9682720188067311e+01*V(F1114) -6.0244302378940429e+00*V(F1115) +1.4237008488801475e+01*V(F1116) -2.4025041419024447e+01*V(F1117) +3.0738279683450497e+01*V(F1118) -2.9125313081601632e+01*V(F1119) +1.9829732088716586e+01*V(F1120) -9.1997216684471610e+00*V(F1121) -1.0664722263792714e+00*V(F1122) +2.5246991424889069e+00*V(F1123) -4.2614636907118788e+00*V(F1124) +5.4529813111071848e+00*V(F1125) -5.1602421004473422e+00*V(F1126) +3.5167218068366966e+00*V(F1127) -1.6281950360916542e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1084)));
	I(F1085)<+( +2.6614508239772340e-27*V(reduced_0) -1.9905767347144896e-27*V(reduced_1) -1.1987357426788217e+00*V(F841) -4.4204326215226546e+00*V(F850) +1.0003691345142009e+01*V(F859) -9.2923028793806335e+00*V(F868) +9.2299605511804845e+00*V(F877) -6.7474610843307214e+00*V(F886) +3.6922341835617627e+00*V(F895) -1.7288923609618005e+00*V(F904) -3.1126900105200439e-01*V(F913) -4.1341855486486900e-01*V(F1001) -1.5274813051580607e+00*V(F1009) +3.4563568243789979e+00*V(F1017) -3.2117827964209993e+00*V(F1025) +3.1901705361089268e+00*V(F1033) -2.3321516330585661e+00*V(F1041) +1.2761330440011109e+00*V(F1049) -5.9740857093334931e-01*V(F1057) -1.0731851880817167e-01*V(F1065) +1.9936340981467391e+00*V(F1066) -5.2391038509046561e+00*V(F1067) +9.7425538707687913e+00*V(F1068) -1.3271345105753207e+01*V(F1069) +1.3570540338633327e+01*V(F1070) -1.0371135583455713e+01*V(F1071) +5.1842269827122491e+00*V(F1072) +7.4598342274050449e+00*V(F1073) -1.9579092490906870e+01*V(F1074) +3.6405523280550156e+01*V(F1075) -4.9592866427236807e+01*V(F1076) +5.0706676266216469e+01*V(F1077) -3.8836334054451036e+01*V(F1078) +1.9396291838870759e+01*V(F1079) -1.6866704679564048e+01*V(F1080) +4.4271832741637070e+01*V(F1081) -8.2319886303653050e+01*V(F1082) +1.1213884754163081e+02*V(F1083) -1.1465797430044213e+02*V(F1084) +8.7804955701607739e+01*V(F1085) -4.3855372303378608e+01*V(F1086) +1.5711600394472041e+01*V(F1087) -4.1229909416391621e+01*V(F1088) +7.6662281983354688e+01*V(F1089) -1.0443232681196409e+02*V(F1090) +1.0677661741002032e+02*V(F1091) -8.1803557361226709e+01*V(F1092) +4.0851083023140902e+01*V(F1093) -1.5603846984584857e+01*V(F1094) +4.0947673289696844e+01*V(F1095) -7.6137569846178735e+01*V(F1096) +1.0371751972928823e+02*V(F1097) -1.0604585477770708e+02*V(F1098) +8.1241906249282010e+01*V(F1099) -4.0570964507468020e+01*V(F1100) +1.1407478719370326e+01*V(F1101) -2.9935445037448467e+01*V(F1102) +5.5661561835963973e+01*V(F1103) -7.5824320442008769e+01*V(F1104) +7.7526468647292049e+01*V(F1105) -5.9393508864122154e+01*V(F1106) +2.9660139088502543e+01*V(F1107) -6.2411754767658953e+00*V(F1108) +1.6378292674055899e+01*V(F1109) -3.0453608519177447e+01*V(F1110) +4.1485066287158482e+01*V(F1111) -4.2416387034383320e+01*V(F1112) +3.2494661157131432e+01*V(F1113) -1.6227456808303348e+01*V(F1114) +2.9172616596135330e+00*V(F1115) -7.6567357199527271e+00*V(F1116) +1.4237008488969305e+01*V(F1117) -1.9394142820337859e+01*V(F1118) +1.9829732088716778e+01*V(F1119) -1.5187332807513611e+01*V(F1120) +7.5851706295187933e+00*V(F1121) +5.1652557488193052e-01*V(F1122) -1.3576490566432460e+00*V(F1123) +2.5246991425185388e+00*V(F1124) -3.4391431677235706e+00*V(F1125) +3.5167218068365611e+00*V(F1126) -2.6867190595572086e+00*V(F1127) +1.3431914360379211e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1085)));
	I(F1086)<+( -1.7028334762519920e-26*V(reduced_0) +1.2791349235625832e-26*V(reduced_1) +1.0002034477519641e+00*V(F841) +3.6928479851670746e+00*V(F850) -8.3564854184933797e+00*V(F859) +7.7640863127100808e+00*V(F868) -7.7118989017324395e+00*V(F877) +5.6377179627633982e+00*V(F886) -3.0849355751260354e+00*V(F895) +1.4443079512842949e+00*V(F904) +2.5966917120381788e-01*V(F913) +1.1949153117044789e-01*V(F1001) +4.4254745869459716e-01*V(F1009) -1.0012390693905919e+00*V(F1017) +9.3082249718757404e-01*V(F1025) -9.2453612384164952e-01*V(F1033) +6.7588006178873961e-01*V(F1041) -3.6982558639419777e-01*V(F1049) +1.7307966461053051e-01*V(F1057) +3.1007351448302817e-02*V(F1065) -6.5945939705599488e-01*V(F1066) +1.9936340981800980e+00*V(F1067) -4.1163689601593587e+00*V(F1068) +6.0010019365055483e+00*V(F1069) -6.2847041652995319e+00*V(F1070) +5.1842269827110012e+00*V(F1071) -3.2203643454978730e+00*V(F1072) -2.4690495132574326e+00*V(F1073) +7.4598342275271570e+00*V(F1074) -1.5405309136319474e+01*V(F1075) +2.2461705847114104e+01*V(F1076) -2.3525015559365993e+01*V(F1077) +1.9396291838871260e+01*V(F1078) -1.2130744297846356e+01*V(F1079) +5.5823226077222516e+00*V(F1080) -1.6866704679841600e+01*V(F1081) +3.4831085585198892e+01*V(F1082) -5.0784998897012976e+01*V(F1083) +5.3188901236880675e+01*V(F1084) -4.3855372303378608e+01*V(F1085) +2.7416374786789834e+01*V(F1086) -5.2006141185248529e+00*V(F1087) +1.5711600394730604e+01*V(F1088) -3.2446741710822849e+01*V(F1089) +4.7309852069540810e+01*V(F1090) -4.9549830409301478e+01*V(F1091) +4.0851083023141271e+01*V(F1092) -2.5571411589379601e+01*V(F1093) +5.1649159703407612e+00*V(F1094) -1.5603846984841521e+01*V(F1095) +3.2224160495526853e+01*V(F1096) -4.6985242220517513e+01*V(F1097) +4.9209821127129381e+01*V(F1098) -4.0570964507468148e+01*V(F1099) +2.5394317349199824e+01*V(F1100) -3.7759127236854755e+00*V(F1101) +1.1407478719557997e+01*V(F1102) -2.3558074648851438e+01*V(F1103) +3.4349452800136937e+01*V(F1104) -3.5975779309479826e+01*V(F1105) +2.9660139088502703e+01*V(F1106) -1.8565318031743011e+01*V(F1107) +2.0658356462303682e+00*V(F1108) -6.2411754768688006e+00*V(F1109) +1.2888895539591292e+01*V(F1110) -1.8792952896530764e+01*V(F1111) +1.9682720188067698e+01*V(F1112) -1.6227456808303671e+01*V(F1113) +1.0156558785217513e+01*V(F1114) -9.6554763960917733e-01*V(F1115) +2.9172616596623326e+00*V(F1116) -6.0244302380531565e+00*V(F1117) +8.7839071659794836e+00*V(F1118) -9.1997216684481202e+00*V(F1119) +7.5851706295195953e+00*V(F1120) -4.7435981466649766e+00*V(F1121) -1.7084205755811932e-01*V(F1122) +5.1652557488994244e-01*V(F1123) -1.0664722264059021e+00*V(F1124) +1.5547099079108908e+00*V(F1125) -1.6281950360909541e+00*V(F1126) +1.3431914360373374e+00*V(F1127) -8.3349773503242985e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1086)));
	I(F1087)<+( +1.8296148226677374e-25*V(reduced_0) -1.3362074569045949e-25*V(reduced_1) -1.4820116388927529e-01*V(F841) -5.7565653919329596e-01*V(F850) +9.3082249721014310e-01*V(F859) -1.5831459538290402e+00*V(F868) +1.3707863256846951e+00*V(F877) -1.0966914735672784e+00*V(F886) +6.7588006180528493e-01*V(F895) -3.6619554294688228e-01*V(F904) -8.1071093004805639e-02*V(F913) -1.2405482244869610e+00*V(F1001) -4.8041279220711592e+00*V(F1009) +7.7640863123540633e+00*V(F1017) -1.3208964158741782e+01*V(F1025) +1.1432607970023447e+01*V(F1033) -9.1470727936120237e+00*V(F1041) +5.6377179625020570e+00*V(F1049) -3.0559347097756597e+00*V(F1057) -6.7873832729395556e-01*V(F1065) +3.9935572664555616e+00*V(F1066) -6.4292883031752988e+00*V(F1067) +7.7940291484037738e+00*V(F1068) -7.4421970545165808e+00*V(F1069) +5.1049583447582156e+00*V(F1070) -2.4724296790886831e+00*V(F1071) +8.1783268484117555e-01*V(F1072) +1.5769701776380343e+01*V(F1073) -2.5220946527443907e+01*V(F1074) +3.0588977274583357e+01*V(F1075) -2.9206446502334902e+01*V(F1076) +2.0031279126745730e+01*V(F1077) -9.6999628052794868e+00*V(F1078) +3.2104161428183402e+00*V(F1079) -2.5571411588427427e+01*V(F1080) +4.0851083021683060e+01*V(F1081) -4.9549830407547525e+01*V(F1082) +4.7309852068034836e+01*V(F1083) -3.2446741709977054e+01*V(F1084) +1.5711600394472041e+01*V(F1085) -5.2006141185248529e+00*V(F1086) +4.3424891596181112e+01*V(F1087) -6.9415169703508781e+01*V(F1088) +8.4192591495523232e+01*V(F1089) -8.0386971340149515e+01*V(F1090) +5.5132904936020587e+01*V(F1091) -2.6697265831225998e+01*V(F1092) +8.8364446104709025e+00*V(F1093) -3.7680409775297178e+01*V(F1094) +6.0181336061250214e+01*V(F1095) -7.2997465196240640e+01*V(F1096) +6.9697352992088071e+01*V(F1097) -4.7800626490330252e+01*V(F1098) +2.3146236691204905e+01*V(F1099) -7.6616730748890491e+00*V(F1100) +3.0137781265515223e+01*V(F1101) -4.8139862590120927e+01*V(F1102) +5.8391200827772025e+01*V(F1103) -5.5751471251684080e+01*V(F1104) +3.8236193486490805e+01*V(F1105) -1.8514953256586431e+01*V(F1106) +6.1286057579699218e+00*V(F1107) -1.8565318031055913e+01*V(F1108) +2.9660139087454837e+01*V(F1109) -3.5975779308219920e+01*V(F1110) +3.4349452799056316e+01*V(F1111) -2.3558074648245917e+01*V(F1112) +1.1407478719374168e+01*V(F1113) -3.7759127236866101e+00*V(F1114) +1.0034175411129343e+01*V(F1115) -1.6046351536031711e+01*V(F1116) +1.9461798707238753e+01*V(F1117) -1.8582166851489315e+01*V(F1118) +1.2744576020096567e+01*V(F1119) -6.1714286458893621e+00*V(F1120) +2.0425879859805955e+00*V(F1121) +2.1825526913309767e+00*V(F1122) -3.5150593884060988e+00*V(F1123) +4.2610836446593785e+00*V(F1124) -4.0687467160357436e+00*V(F1125) +2.7909701919064798e+00*V(F1126) -1.3517332011942649e+00*V(F1127) +4.4711280154584349e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1087)));
	I(F1088)<+( -2.9089251638072216e-26*V(reduced_0) +2.1347652544502845e-26*V(reduced_1) +5.1275837742218855e-01*V(F841) +1.9870900058321659e+00*V(F850) -3.2117827965421522e+00*V(F859) +5.4638115937486029e+00*V(F868) -4.7294675861941426e+00*V(F877) +3.7839373858450456e+00*V(F886) -2.3321516331469456e+00*V(F895) +1.2640135007615880e+00*V(F904) +2.8053321165837697e-01*V(F913) +1.4868015713462992e+00*V(F1001) +5.7509218783215701e+00*V(F1009) -9.2923028789150592e+00*V(F1017) +1.5810691769464416e+01*V(F1025) -1.3682308359486360e+01*V(F1033) +1.0947247527196533e+01*V(F1041) -6.7474610839885019e+00*V(F1049) +3.6581291933685463e+00*V(F1057) +8.1352507507477956e-01*V(F1065) -6.4292883031723997e+00*V(F1066) +1.2861811619261088e+01*V(F1067) -1.6829864738763305e+01*V(F1068) +1.6458798722041141e+01*V(F1069) -1.2082480053521037e+01*V(F1070) +6.4974051064735754e+00*V(F1071) -2.4724296791296601e+00*V(F1072) -2.5220946527448532e+01*V(F1073) +5.0497190279102931e+01*V(F1074) -6.5936880553312093e+01*V(F1075) +6.4488332271875777e+01*V(F1076) -4.7340143398532376e+01*V(F1077) +2.5459704356653354e+01*V(F1078) -9.6999628054396201e+00*V(F1079) +4.0851083021687217e+01*V(F1080) -8.1803557358849915e+01*V(F1081) +1.0677661740729948e+02*V(F1082) -1.0443232680986637e+02*V(F1083) +7.6662281982454431e+01*V(F1084) -4.1229909416391621e+01*V(F1085) +1.5711600394730604e+01*V(F1086) -6.9415169703508781e+01*V(F1087) +1.3899166209017744e+02*V(F1088) -1.8145899601755252e+02*V(F1089) +1.7747369833196484e+02*V(F1090) -1.3028117897365593e+02*V(F1091) +7.0066202426501761e+01*V(F1092) -2.6697265831664740e+01*V(F1093) +6.0181336061245318e+01*V(F1094) -1.2051570022180623e+02*V(F1095) +1.5729487343702678e+02*V(F1096) -1.5384189992382287e+02*V(F1097) +1.1293305571556409e+02*V(F1098) -6.0736974833675895e+01*V(F1099) +2.3146236691583876e+01*V(F1100) -4.8139862590116941e+01*V(F1101) +9.6400783863047550e+01*V(F1102) -1.2582494325723815e+02*V(F1103) +1.2306263882623054e+02*V(F1104) -9.0338489882896155e+01*V(F1105) +4.8585227421809535e+01*V(F1106) -1.8514953256889644e+01*V(F1107) +2.9660139087449444e+01*V(F1108) -5.9393508862409803e+01*V(F1109) +7.7526468645335044e+01*V(F1110) -7.5824320440504039e+01*V(F1111) +5.5661561835323738e+01*V(F1112) -2.9935445037455580e+01*V(F1113) +1.1407478719560540e+01*V(F1114) -1.6046351536020197e+01*V(F1115) +3.2128295822854227e+01*V(F1116) -4.1950289688232331e+01*V(F1117) +4.1028746423885927e+01*V(F1118) -3.0118721075456502e+01*V(F1119) +1.6197982285742551e+01*V(F1120) -6.1714286459889038e+00*V(F1121) -3.5150593884147554e+00*V(F1122) +7.0315467697569130e+00*V(F1123) -9.2019944042795387e+00*V(F1124) +8.9990663594984301e+00*V(F1125) -6.6062644258406484e+00*V(F1126) +3.5525281151699777e+00*V(F1127) -1.3517332012182692e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1088)));
	I(F1089)<+( +3.3187020427970581e-25*V(reduced_0) -2.4470511983871801e-25*V(reduced_1) -1.1468835379776769e+00*V(F841) -4.4402054812424359e+00*V(F850) +7.1756042116900085e+00*V(F859) -1.2208098291893121e+01*V(F868) +1.0565964300547954e+01*V(F877) -8.4537216544907725e+00*V(F886) +5.2104158117235144e+00*V(F895) -2.8244297484504131e+00*V(F904) -6.2750135953469788e-01*V(F913) -1.8761111110700113e+00*V(F1001) -7.2577119258571567e+00*V(F1009) +1.1727231375268847e+01*V(F1017) -1.9953432333185379e+01*V(F1025) +1.7267664105232843e+01*V(F1033) -1.3815868647800935e+01*V(F1041) +8.5155378013688328e+00*V(F1049) -4.6165991725138307e+00*V(F1057) -1.0265338666731529e+00*V(F1065) +7.7940291484003490e+00*V(F1066) -1.6829864738761803e+01*V(F1067) +2.4698252887265159e+01*V(F1068) -2.6095144505471698e+01*V(F1069) +2.0393514600795093e+01*V(F1070) -1.2082480053664218e+01*V(F1071) +5.1049583448923794e+00*V(F1072) +3.0588977274589094e+01*V(F1073) -6.5936880553313856e+01*V(F1074) +9.6843852485384303e+01*V(F1075) -1.0221021480354010e+02*V(F1076) +7.9887247058077762e+01*V(F1077) -4.7340143399089278e+01*V(F1078) +2.0031279127269368e+01*V(F1079) -4.9549830407552854e+01*V(F1080) +1.0677661740730066e+02*V(F1081) -1.5684881126073464e+02*V(F1082) +1.6550939018402721e+02*V(F1083) -1.2936431981555609e+02*V(F1084) +7.6662281983354688e+01*V(F1085) -3.2446741710822849e+01*V(F1086) +8.4192591495523232e+01*V(F1087) -1.8145899601755252e+02*V(F1088) +2.6653243326807353e+02*V(F1089) -2.8127788228143430e+02*V(F1090) +2.1984809044516609e+02*V(F1091) -1.3028117897518652e+02*V(F1092) +5.5132904937456452e+01*V(F1093) -7.2997465196234302e+01*V(F1094) +1.5729487343702547e+02*V(F1095) -2.3106413709587628e+02*V(F1096) +2.4381306070013477e+02*V(F1097) -1.9056830401339155e+02*V(F1098) +1.1293305571688889e+02*V(F1099) -4.7800626491571158e+01*V(F1100) +5.8391200827766866e+01*V(F1101) -1.2582494325723711e+02*V(F1102) +1.8483268250134850e+02*V(F1103) -1.9503431283975652e+02*V(F1104) +1.5244173463443192e+02*V(F1105) -9.0338489883956044e+01*V(F1106) +3.8236193487483590e+01*V(F1107) -3.5975779308212921e+01*V(F1108) +7.7526468645333622e+01*V(F1109) -1.1388127499460570e+02*V(F1110) +1.2017035752892657e+02*V(F1111) -9.3926650033461101e+01*V(F1112) +5.5661561835976684e+01*V(F1113) -2.3558074648856515e+01*V(F1114) +1.9461798707223796e+01*V(F1115) -4.1950289688229375e+01*V(F1116) +6.1614660134061360e+01*V(F1117) -6.5027813287330019e+01*V(F1118) +5.0825665691959749e+01*V(F1119) -3.0118721075809457e+01*V(F1120) +1.2744576020423722e+01*V(F1121) +4.2610836446706122e+00*V(F1122) -9.2019944042817876e+00*V(F1123) +1.3503521782562846e+01*V(F1124) -1.4268145479559065e+01*V(F1125) +1.1150568036049791e+01*V(F1126) -6.6062644259198802e+00*V(F1127) +2.7909701919839369e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1089)));
	I(F1090)<+( -1.4478644014460003e-25*V(reduced_0) +1.0725444110970956e-25*V(reduced_1) +1.7490041311130549e+00*V(F841) +6.7679694597910194e+00*V(F850) -1.0936444836932122e+01*V(F859) +1.8607424402497301e+01*V(F868) -1.6103448991578944e+01*V(F877) +1.2884315937185942e+01*V(F886) -7.9413029657528540e+00*V(F895) +4.3050953675431654e+00*V(F904) +9.5697020405954325e-01*V(F913) +1.7490041310292230e+00*V(F1001) +6.7679694594740551e+00*V(F1009) -1.0936444836416483e+01*V(F1017) +1.8607424401615660e+01*V(F1025) -1.6103448990810936e+01*V(F1033) +1.2884315936571532e+01*V(F1041) -7.9413029653720262e+00*V(F1049) +4.3050953673304644e+00*V(F1057) +9.5697020402147759e-01*V(F1065) -7.4421970545134579e+00*V(F1066) +1.6458798722039887e+01*V(F1067) -2.6095144505470635e+01*V(F1068) +3.0676262008404130e+01*V(F1069) -2.6095144505729234e+01*V(F1070) +1.6458798722374805e+01*V(F1071) -7.4421970547555665e+00*V(F1072) -2.9206446502340199e+01*V(F1073) +6.4488332271877496e+01*V(F1074) -1.0221021480354112e+02*V(F1075) +1.2024883014293786e+02*V(F1076) -1.0221021480454110e+02*V(F1077) +6.4488332273173313e+01*V(F1078) -2.9206446503267205e+01*V(F1079) +4.7309852068039788e+01*V(F1080) -1.0443232680986769e+02*V(F1081) +1.6550939018402769e+02*V(F1082) -1.9474583981440199e+02*V(F1083) +1.6550939018564571e+02*V(F1084) -1.0443232681196409e+02*V(F1085) +4.7309852069540810e+01*V(F1086) -8.0386971340149515e+01*V(F1087) +1.7747369833196484e+02*V(F1088) -2.8127788228143430e+02*V(F1089) +3.3093975575540401e+02*V(F1090) -2.8127788228418660e+02*V(F1091) +1.7747369833553151e+02*V(F1092) -8.0386971342706730e+01*V(F1093) +6.9697352992082187e+01*V(F1094) -1.5384189992382130e+02*V(F1095) +2.4381306070013429e+02*V(F1096) -2.8688967109562742e+02*V(F1097) +2.4381306070251804e+02*V(F1098) -1.5384189992691043e+02*V(F1099) +6.9697352994298583e+01*V(F1100) -5.5751471251679277e+01*V(F1101) +1.2306263882622926e+02*V(F1102) -1.9503431283975610e+02*V(F1103) +2.2948972827849948e+02*V(F1104) -1.9503431284166319e+02*V(F1105) +1.2306263882870059e+02*V(F1106) -5.5751471253452571e+01*V(F1107) +3.4349452799049800e+01*V(F1108) -7.5824320440502362e+01*V(F1109) +1.2017035752892609e+02*V(F1110) -1.4139702041253412e+02*V(F1111) +1.2017035753010158e+02*V(F1112) -7.5824320442025879e+01*V(F1113) +3.4349452800144235e+01*V(F1114) -1.8582166851475375e+01*V(F1115) +4.1028746423882424e+01*V(F1116) -6.5027813287328968e+01*V(F1117) +7.6505195138662756e+01*V(F1118) -6.5027813287966339e+01*V(F1119) +4.1028746424709105e+01*V(F1120) -1.8582166852072927e+01*V(F1121) -4.0687467160462125e+00*V(F1122) +8.9990663595010751e+00*V(F1123) -1.4268145479559884e+01*V(F1124) +1.6772220343711307e+01*V(F1125) -1.4268145479700310e+01*V(F1126) +8.9990663596825069e+00*V(F1127) -4.0687467161729405e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1090)));
	I(F1091)<+( +3.3759167930123763e-25*V(reduced_0) -2.5121673649009096e-25*V(reduced_1) -1.8761111111637168e+00*V(F841) -7.2577119262116208e+00*V(F850) +1.1727231375845406e+01*V(F859) -1.9953432334171087e+01*V(F868) +1.7267664106091384e+01*V(F877) -1.3815868648487776e+01*V(F886) +8.5155378017945011e+00*V(F895) -4.6165991727514220e+00*V(F904) -1.0265338667158865e+00*V(F913) -1.1468835379266820e+00*V(F1001) -4.4402054810498175e+00*V(F1009) +7.1756042113766014e+00*V(F1017) -1.2208098291357127e+01*V(F1025) +1.0565964300080948e+01*V(F1033) -8.4537216541171620e+00*V(F1041) +5.2104158114918935e+00*V(F1049) -2.8244297483209002e+00*V(F1057) -6.2750135951172148e-01*V(F1065) +5.1049583447562261e+00*V(F1066) -1.2082480053520174e+01*V(F1067) +2.0393514600794362e+01*V(F1068) -2.6095144505728246e+01*V(F1069) +2.4698252887709774e+01*V(F1070) -1.6829864739196260e+01*V(F1071) +7.7940291486822089e+00*V(F1072) +2.0031279126749105e+01*V(F1073) -4.7340143398533534e+01*V(F1074) +7.9887247058078486e+01*V(F1075) -1.0221021480454186e+02*V(F1076) +9.6843852487111803e+01*V(F1077) -6.5936880554994900e+01*V(F1078) +3.0588977275669070e+01*V(F1079) -3.2446741709980216e+01*V(F1080) +7.6662281982455340e+01*V(F1081) -1.2936431981555646e+02*V(F1082) +1.6550939018564591e+02*V(F1083) -1.5684881126352812e+02*V(F1084) +1.0677661741002032e+02*V(F1085) -4.9549830409301478e+01*V(F1086) +5.5132904936020587e+01*V(F1087) -1.3028117897365593e+02*V(F1088) +2.1984809044516609e+02*V(F1089) -2.8127788228418660e+02*V(F1090) +2.6653243327282451e+02*V(F1091) -1.8145899602217924e+02*V(F1092) +8.4192591498501884e+01*V(F1093) -4.7800626490326472e+01*V(F1094) +1.1293305571556304e+02*V(F1095) -1.9056830401339113e+02*V(F1096) +2.4381306070251784e+02*V(F1097) -2.3106413709999026e+02*V(F1098) +1.5729487344103214e+02*V(F1099) -7.2997465198815661e+01*V(F1100) +3.8236193486487743e+01*V(F1101) -9.0338489882895288e+01*V(F1102) +1.5244173463443153e+02*V(F1103) -1.9503431284166308e+02*V(F1104) +1.8483268250463973e+02*V(F1105) -1.2582494326044261e+02*V(F1106) +5.8391200829832165e+01*V(F1107) -2.3558074648241764e+01*V(F1108) +5.5661561835322580e+01*V(F1109) -9.3926650033460646e+01*V(F1110) +1.2017035753010146e+02*V(F1111) -1.1388127499663408e+02*V(F1112) +7.7526468647309514e+01*V(F1113) -3.5975779309487436e+01*V(F1114) +1.2744576020087688e+01*V(F1115) -3.0118721075454065e+01*V(F1116) +5.0825665691958804e+01*V(F1117) -6.5027813287966168e+01*V(F1118) +6.1614660135160406e+01*V(F1119) -4.1950289689300895e+01*V(F1120) +1.9461798707919225e+01*V(F1121) +2.7909701919131460e+00*V(F1122) -6.6062644258424861e+00*V(F1123) +1.1150568036050515e+01*V(F1124) -1.4268145479700467e+01*V(F1125) +1.3503521782806082e+01*V(F1126) -9.2019944045177624e+00*V(F1127) +4.2610836448186689e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1091)));
	I(F1092)<+( -3.0100975877711683e-26*V(reduced_0) +2.2499096950934976e-26*V(reduced_1) +1.4868015714219436e+00*V(F841) +5.7509218786077945e+00*V(F850) -9.2923028793805784e+00*V(F859) +1.5810691770260219e+01*V(F868) -1.3682308360179407e+01*V(F877) +1.0947247527750973e+01*V(F886) -6.7474610843320795e+00*V(F895) +3.6581291935602067e+00*V(F904) +8.1352507510940375e-01*V(F913) +5.1275837740270080e-01*V(F1001) +1.9870900057587479e+00*V(F1009) -3.2117827964226251e+00*V(F1017) +5.4638115935440892e+00*V(F1025) -4.7294675860158524e+00*V(F1033) +3.7839373857024139e+00*V(F1041) -2.3321516330584737e+00*V(F1049) +1.2640135007119888e+00*V(F1057) +2.8053321164975736e-01*V(F1065) -2.4724296790878277e+00*V(F1066) +6.4974051064730727e+00*V(F1067) -1.2082480053663568e+01*V(F1068) +1.6458798722373910e+01*V(F1069) -1.6829864739195067e+01*V(F1070) +1.2861811619639660e+01*V(F1071) -6.4292883034068886e+00*V(F1072) -9.6999628052809008e+00*V(F1073) +2.5459704356653937e+01*V(F1074) -4.7340143399089783e+01*V(F1075) +6.4488332273173896e+01*V(F1076) -6.5936880554995710e+01*V(F1077) +5.0497190280572944e+01*V(F1078) -2.5220946528346509e+01*V(F1079) +1.5711600394473352e+01*V(F1080) -4.1229909416392005e+01*V(F1081) +7.6662281983354831e+01*V(F1082) -1.0443232681196413e+02*V(F1083) +1.0677661741002034e+02*V(F1084) -8.1803557361226709e+01*V(F1085) +4.0851083023141271e+01*V(F1086) -2.6697265831225998e+01*V(F1087) +7.0066202426501761e+01*V(F1088) -1.3028117897518652e+02*V(F1089) +1.7747369833553151e+02*V(F1090) -1.8145899602217924e+02*V(F1091) +1.3899166209421998e+02*V(F1092) -6.9415169705985420e+01*V(F1093) +2.3146236691203359e+01*V(F1094) -6.0736974833675454e+01*V(F1095) +1.1293305571688880e+02*V(F1096) -1.5384189992691049e+02*V(F1097) +1.5729487344103222e+02*V(F1098) -1.2051570022530643e+02*V(F1099) +6.0181336063391420e+01*V(F1100) -1.8514953256585176e+01*V(F1101) +4.8585227421809194e+01*V(F1102) -9.0338489883955944e+01*V(F1103) +1.2306263882870070e+02*V(F1104) -1.2582494326044271e+02*V(F1105) +9.6400783865847899e+01*V(F1106) -4.8139862591834010e+01*V(F1107) +1.1407478719372456e+01*V(F1108) -2.9935445037455139e+01*V(F1109) +5.5661561835976585e+01*V(F1110) -7.5824320442026021e+01*V(F1111) +7.7526468647309727e+01*V(F1112) -5.9393508864135683e+01*V(F1113) +2.9660139088508949e+01*V(F1114) -6.1714286458857064e+00*V(F1115) +1.6197982285741613e+01*V(F1116) -3.0118721075809283e+01*V(F1117) +4.1028746424709446e+01*V(F1118) -4.1950289689301400e+01*V(F1119) +3.2128295823789450e+01*V(F1120) -1.6046351536597967e+01*V(F1121) -1.3517332011970111e+00*V(F1122) +3.5525281151706949e+00*V(F1123) -6.6062644259200276e+00*V(F1124) +8.9990663596822902e+00*V(F1125) -9.2019944045174338e+00*V(F1126) +7.0315467699640264e+00*V(F1127) -3.5150593885382211e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1092)));
	I(F1093)<+( +1.9259030608310308e-25*V(reduced_0) -1.4457932005466849e-25*V(reduced_1) -1.2405482245447830e+00*V(F841) -4.8041279222900988e+00*V(F850) +7.7640863127100816e+00*V(F859) -1.3208964159350176e+01*V(F868) +1.1432607970553089e+01*V(F877) -9.1470727940357435e+00*V(F886) +5.6377179627645289e+00*V(F895) -3.0559347099217775e+00*V(F904) -6.7873832732074857e-01*V(F913) -1.4820116388561932e-01*V(F1001) -5.7565653917971449e-01*V(F1009) +9.3082249718796672e-01*V(F1017) -1.5831459537910029e+00*V(F1025) +1.3707863256514465e+00*V(F1033) -1.0966914735406796e+00*V(F1041) +6.7588006178874438e-01*V(F1049) -3.6619554293748791e-01*V(F1057) -8.1071093003339229e-02*V(F1065) +8.1783268484088345e-01*V(F1066) -2.4724296791291969e+00*V(F1067) +5.1049583448913909e+00*V(F1068) -7.4421970547540308e+00*V(F1069) +7.7940291486804982e+00*V(F1070) -6.4292883034053059e+00*V(F1071) +3.9935572666079824e+00*V(F1072) +3.2104161428187221e+00*V(F1073) -9.6999628054399150e+00*V(F1074) +2.0031279127269872e+01*V(F1075) -2.9206446503267923e+01*V(F1076) +3.0588977275669883e+01*V(F1077) -2.5220946528347305e+01*V(F1078) +1.5769701776969693e+01*V(F1079) -5.2006141185251442e+00*V(F1080) +1.5711600394730592e+01*V(F1081) -3.2446741710822629e+01*V(F1082) +4.7309852069540419e+01*V(F1083) -4.9549830409301030e+01*V(F1084) +4.0851083023140902e+01*V(F1085) -2.5571411589379601e+01*V(F1086) +8.8364446104709025e+00*V(F1087) -2.6697265831664740e+01*V(F1088) +5.5132904937456452e+01*V(F1089) -8.0386971342706730e+01*V(F1090) +8.4192591498501884e+01*V(F1091) -6.9415169705985420e+01*V(F1092) +4.3424891597801277e+01*V(F1093) -7.6616730748887187e+00*V(F1094) +2.3146236691583944e+01*V(F1095) -4.7800626491571570e+01*V(F1096) +6.9697352994299294e+01*V(F1097) -7.2997465198816471e+01*V(F1098) +6.0181336063392081e+01*V(F1099) -3.7680409776699172e+01*V(F1100) +6.1286057579696500e+00*V(F1101) -1.8514953256889701e+01*V(F1102) +3.8236193487483931e+01*V(F1103) -5.5751471253453161e+01*V(F1104) +5.8391200829832847e+01*V(F1105) -4.8139862591834572e+01*V(F1106) +3.0137781266636992e+01*V(F1107) -3.7759127236862460e+00*V(F1108) +1.1407478719560647e+01*V(F1109) -2.3558074648857037e+01*V(F1110) +3.4349452800145116e+01*V(F1111) -3.5975779309488452e+01*V(F1112) +2.9660139088509784e+01*V(F1113) -1.8565318031747346e+01*V(F1114) +2.0425879859798282e+00*V(F1115) -6.1714286459891863e+00*V(F1116) +1.2744576020424931e+01*V(F1117) -1.8582166852075012e+01*V(F1118) +1.9461798707921574e+01*V(F1119) -1.6046351536599929e+01*V(F1120) +1.0034175411504252e+01*V(F1121) +4.4711280154642269e-01*V(F1122) -1.3517332012180727e+00*V(F1123) +2.7909701919830625e+00*V(F1124) -4.0687467161714279e+00*V(F1125) +4.2610836448169698e+00*V(F1126) -3.5150593885368027e+00*V(F1127) +2.1825526914144038e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1093)));
	I(F1094)<+( -7.9136599140759663e-26*V(reduced_0) +5.7755882971691837e-26*V(reduced_1) +1.3280266944190972e-01*V(F841) +5.4502753185456831e-01*V(F850) -9.2453612386401485e-01*V(F859) +1.3707863256846562e+00*V(F868) -1.8703438394788638e+00*V(F877) +1.3707863256850135e+00*V(F886) -9.2453612386440631e-01*V(F895) +5.4502753185489783e-01*V(F904) +1.3280266944218894e-01*V(F913) +1.1117172852899917e+00*V(F1001) +4.5484537331169355e+00*V(F1009) -7.7118989013783201e+00*V(F1017) +1.1432607970028181e+01*V(F1025) -1.5603755080201090e+01*V(F1033) +1.1432607970024968e+01*V(F1041) -7.7118989013755934e+00*V(F1049) +4.5484537331081345e+00*V(F1057) +1.1117172853006849e+00*V(F1065) -3.5774577275386896e+00*V(F1066) +5.7601541176984128e+00*V(F1067) -6.9827935374364998e+00*V(F1068) +6.6675892952172360e+00*V(F1069) -4.5736305629776961e+00*V(F1070) +2.2151044657514847e+00*V(F1071) -7.3270606768502122e-01*V(F1072) -1.4931715508053729e+01*V(F1073) +2.3880046023418949e+01*V(F1074) -2.8962738691211687e+01*V(F1075) +2.7653702024370098e+01*V(F1076) -1.8966315694093858e+01*V(F1077) +9.1842575663512385e+00*V(F1078) -3.0397397932144927e+00*V(F1079) +2.5394317348254027e+01*V(F1080) -4.0570964506020381e+01*V(F1081) +4.9209821125388018e+01*V(F1082) -4.6985242219022375e+01*V(F1083) +3.2224160494687219e+01*V(F1084) -1.5603846984584857e+01*V(F1085) +5.1649159703407612e+00*V(F1086) -3.7680409775297178e+01*V(F1087) +6.0181336061245318e+01*V(F1088) -7.2997465196234302e+01*V(F1089) +6.9697352992082187e+01*V(F1090) -4.7800626490326472e+01*V(F1091) +2.3146236691203359e+01*V(F1092) -7.6616730748887187e+00*V(F1093) +5.1328158651903799e+01*V(F1094) -8.2032345350782975e+01*V(F1095) +9.9497184145710463e+01*V(F1096) -9.4999607917069184e+01*V(F1097) +6.5154614308284721e+01*V(F1098) -3.1549970934697189e+01*V(F1099) +1.0442808341139559e+01*V(F1100) -3.7680409775306160e+01*V(F1101) +6.0181336061265355e+01*V(F1102) -7.2997465196259142e+01*V(F1103) +6.9697352992105735e+01*V(F1104) -4.7800626490342253e+01*V(F1105) +2.3146236691210660e+01*V(F1106) -7.6616730748909188e+00*V(F1107) +2.5394317348264064e+01*V(F1108) -4.0570964506041818e+01*V(F1109) +4.9209821125414507e+01*V(F1110) -4.6985242219047507e+01*V(F1111) +3.2224160494704094e+01*V(F1112) -1.5603846984592717e+01*V(F1113) +5.1649159703431602e+00*V(F1114) -1.4931715508060595e+01*V(F1115) +2.3880046023440794e+01*V(F1116) -2.8962738691239053e+01*V(F1117) +2.7653702024395880e+01*V(F1118) -1.8966315694110875e+01*V(F1119) +9.1842575663588715e+00*V(F1120) -3.0397397932166377e+00*V(F1121) -3.5774577275483415e+00*V(F1122) +5.7601541177058735e+00*V(F1123) -6.9827935374450130e+00*V(F1124) +6.6675892952256381e+00*V(F1125) -4.5736305629839427e+00*V(F1126) +2.2151044657549424e+00*V(F1127) -7.3270606768642332e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1094)));
	I(F1095)<+( +1.2582020420822236e-26*V(reduced_0) -9.2273424733363523e-27*V(reduced_1) -4.5950216693161389e-01*V(F841) -1.8813435066292317e+00*V(F850) +3.1901705362290302e+00*V(F859) -4.7294675861941426e+00*V(F868) +6.4545414541369048e+00*V(F877) -4.7294675861952040e+00*V(F886) +3.1901705362302160e+00*V(F895) -1.8813435066300643e+00*V(F904) -4.5950216693278778e-01*V(F913) -1.3324279958835372e+00*V(F1001) -5.4448309999382820e+00*V(F1009) +9.2299605507173528e+00*V(F1017) -1.3682308359492932e+01*V(F1025) +1.8676495344756443e+01*V(F1033) -1.3682308359487960e+01*V(F1041) +9.2299605507130220e+00*V(F1049) -5.4448309999257196e+00*V(F1057) -1.3324279958977725e+00*V(F1065) +5.7601541176957696e+00*V(F1066) -1.1523014944402213e+01*V(F1067) +1.5078657112998968e+01*V(F1068) -1.4746178309884739e+01*V(F1069) +1.0825242181596767e+01*V(F1070) -5.8213095598639200e+00*V(F1071) +2.2151044657882042e+00*V(F1072) +2.3880046023423098e+01*V(F1073) -4.7812625189413424e+01*V(F1074) +6.2430925467430136e+01*V(F1075) -6.1059420125322383e+01*V(F1076) +4.4823014116095081e+01*V(F1077) -2.4105992583578971e+01*V(F1078) +9.1842575665028114e+00*V(F1079) -4.0570964506023479e+01*V(F1080) +8.1241906246921189e+01*V(F1081) -1.0604585477500481e+02*V(F1082) +1.0371751972720489e+02*V(F1083) -7.6137569845284631e+01*V(F1084) +4.0947673289696844e+01*V(F1085) -1.5603846984841521e+01*V(F1086) +6.0181336061250214e+01*V(F1087) -1.2051570022180623e+02*V(F1088) +1.5729487343702547e+02*V(F1089) -1.5384189992382130e+02*V(F1090) +1.1293305571556304e+02*V(F1091) -6.0736974833675454e+01*V(F1092) +2.3146236691583944e+01*V(F1093) -8.2032345350782975e+01*V(F1094) +1.6425952189824554e+02*V(F1095) -2.1443348091178254e+02*V(F1096) +2.0972449506116857e+02*V(F1097) -1.5395597543957572e+02*V(F1098) +8.2798917099588238e+01*V(F1099) -3.1549970935215516e+01*V(F1100) +6.0181336061258349e+01*V(F1101) -1.2051570022183454e+02*V(F1102) +1.5729487343706381e+02*V(F1103) -1.5384189992385910e+02*V(F1104) +1.1293305571559068e+02*V(F1105) -6.0736974833690120e+01*V(F1106) +2.3146236691589273e+01*V(F1107) -4.0570964506033377e+01*V(F1108) +8.1241906246952666e+01*V(F1109) -1.0604585477504715e+02*V(F1110) +1.0371751972724653e+02*V(F1111) -7.6137569845315113e+01*V(F1112) +4.0947673289713109e+01*V(F1113) -1.5603846984847477e+01*V(F1114) +2.3880046023422533e+01*V(F1115) -4.7812625189434783e+01*V(F1116) +6.2430925467460916e+01*V(F1117) -6.1059420125352979e+01*V(F1118) +4.4823014116117399e+01*V(F1119) -2.4105992583590712e+01*V(F1120) +9.1842575665068349e+00*V(F1121) +5.7601541177196243e+00*V(F1122) -1.1523014944433543e+01*V(F1123) +1.5078657113037615e+01*V(F1124) -1.4746178309922257e+01*V(F1125) +1.0825242181624436e+01*V(F1126) -5.8213095598789968e+00*V(F1127) +2.2151044657941870e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1095)));
	I(F1096)<+( -1.4354438937230528e-25*V(reduced_0) +1.0577271119948426e-25*V(reduced_1) +1.0277850648230606e+00*V(F841) +4.2038941220905253e+00*V(F850) -7.1273928868904557e+00*V(F859) +1.0565964300547977e+01*V(F868) -1.4421312452726124e+01*V(F877) +1.0565964300550316e+01*V(F886) -7.1273928868930652e+00*V(F895) +4.2038941220923265e+00*V(F904) +1.0277850648257125e+00*V(F913) +1.6813115340650149e+00*V(F1001) +6.8714266222378608e+00*V(F1009) -1.1648536786170842e+01*V(F1017) +1.7267664105241121e+01*V(F1025) -2.3570232480880936e+01*V(F1033) +1.7267664105234871e+01*V(F1041) -1.1648536786165383e+01*V(F1049) +6.8714266222220237e+00*V(F1057) +1.6813115340829645e+00*V(F1065) -6.9827935374333796e+00*V(F1066) +1.5078657112997606e+01*V(F1067) -2.2127952399164208e+01*V(F1068) +2.3379971184219421e+01*V(F1069) -1.8271548080386395e+01*V(F1070) +1.0825242181725073e+01*V(F1071) -4.5736305630979155e+00*V(F1072) -2.8962738691216828e+01*V(F1073) +6.2430925467431749e+01*V(F1074) -9.1694860808716498e+01*V(F1075) +9.6775446301069962e+01*V(F1076) -7.5639484265621746e+01*V(F1077) +4.4823014116622304e+01*V(F1078) -1.8966315694589532e+01*V(F1079) +4.9209821125391962e+01*V(F1080) -1.0604585477500576e+02*V(F1081) +1.5577401379083460e+02*V(F1082) -1.6437711965991721e+02*V(F1083) +1.2847916438396359e+02*V(F1084) -7.6137569846178735e+01*V(F1085) +3.2224160495526853e+01*V(F1086) -7.2997465196240640e+01*V(F1087) +1.5729487343702678e+02*V(F1088) -2.3106413709587628e+02*V(F1089) +2.4381306070013429e+02*V(F1090) -1.9056830401339113e+02*V(F1091) +1.1293305571688880e+02*V(F1092) -4.7800626491571570e+01*V(F1093) +9.9497184145710463e+01*V(F1094) -2.1443348091178254e+02*V(F1095) +3.1497420040071927e+02*V(F1096) -3.3238870030931963e+02*V(F1097) +2.5979746079694490e+02*V(F1098) -1.5395597544138391e+02*V(F1099) +6.5154614309981056e+01*V(F1100) -7.2997465196250062e+01*V(F1101) +1.5729487343706199e+02*V(F1102) -2.3106413709593039e+02*V(F1103) +2.4381306070019167e+02*V(F1104) -1.9056830401343603e+02*V(F1105) +1.1293305571691528e+02*V(F1106) -4.7800626491582243e+01*V(F1107) +4.9209821125403550e+01*V(F1108) -1.0604585477504493e+02*V(F1109) +1.5577401379089468e+02*V(F1110) -1.6437711965998099e+02*V(F1111) +1.2847916438401353e+02*V(F1112) -7.6137569846208194e+01*V(F1113) +3.2224160495538861e+01*V(F1114) -2.8962738691215311e+01*V(F1115) +6.2430925467456234e+01*V(F1116) -9.1694860808757269e+01*V(F1117) +9.6775446301114158e+01*V(F1118) -7.5639484265656435e+01*V(F1119) +4.4823014116642625e+01*V(F1120) -1.8966315694597309e+01*V(F1121) -6.9827935374628600e+00*V(F1122) +1.5078657113041187e+01*V(F1123) -2.2127952399224448e+01*V(F1124) +2.3379971184282027e+01*V(F1125) -1.8271548080435320e+01*V(F1126) +1.0825242181754183e+01*V(F1127) -4.5736305631106298e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1096)));
	I(F1097)<+( +6.2624744936546645e-26*V(reduced_0) -4.6360682857278106e-26*V(reduced_1) -1.5673934159675711e+00*V(F841) -6.4077585083966406e+00*V(F850) +1.0863022981632039e+01*V(F859) -1.6103448991578986e+01*V(F868) +2.1980440787249862e+01*V(F877) -1.6103448991582518e+01*V(F886) +1.0863022981635995e+01*V(F895) -6.4077585083993638e+00*V(F904) -1.5673934159716216e+00*V(F913) -1.5673934158924299e+00*V(F1001) -6.4077585080963528e+00*V(F1009) +1.0863022981119153e+01*V(F1017) -1.6103448990818507e+01*V(F1025) +2.1980440786207982e+01*V(F1033) -1.6103448990812858e+01*V(F1041) +1.0863022981114254e+01*V(F1049) -6.4077585080819421e+00*V(F1057) -1.5673934159089140e+00*V(F1065) +6.6675892952143876e+00*V(F1066) -1.4746178309883586e+01*V(F1067) +2.3379971184218451e+01*V(F1068) -2.7484000081679916e+01*V(F1069) +2.3379971184450199e+01*V(F1070) -1.4746178310183737e+01*V(F1071) +6.6675892954313891e+00*V(F1072) +2.7653702024374859e+01*V(F1073) -6.1059420125323904e+01*V(F1074) +9.6775446301070943e+01*V(F1075) -1.1385529747777879e+02*V(F1076) +9.6775446302017656e+01*V(F1077) -6.1059420126550791e+01*V(F1078) +2.7653702025252624e+01*V(F1079) -4.6985242219026063e+01*V(F1080) +1.0371751972720590e+02*V(F1081) -1.6437711965991778e+02*V(F1082) +1.9341195067780347e+02*V(F1083) -1.6437711966152480e+02*V(F1084) +1.0371751972928823e+02*V(F1085) -4.6985242220517513e+01*V(F1086) +6.9697352992088071e+01*V(F1087) -1.5384189992382287e+02*V(F1088) +2.4381306070013477e+02*V(F1089) -2.8688967109562742e+02*V(F1090) +2.4381306070251784e+02*V(F1091) -1.5384189992691049e+02*V(F1092) +6.9697352994299294e+01*V(F1093) -9.4999607917069184e+01*V(F1094) +2.0972449506116857e+02*V(F1095) -3.3238870030931963e+02*V(F1096) +3.9108396450179754e+02*V(F1097) -3.3238870031257130e+02*V(F1098) +2.0972449506538217e+02*V(F1099) -9.4999607920090199e+01*V(F1100) +6.9697352992097279e+01*V(F1101) -1.5384189992385697e+02*V(F1102) +2.4381306070019099e+02*V(F1103) -2.8688967109569450e+02*V(F1104) +2.4381306070257492e+02*V(F1105) -1.5384189992694630e+02*V(F1106) +6.9697352994314741e+01*V(F1107) -4.6985242219037310e+01*V(F1108) +1.0371751972724398e+02*V(F1109) -1.6437711965998020e+02*V(F1110) +1.9341195067787811e+02*V(F1111) -1.6437711966158813e+02*V(F1112) +1.0371751972932815e+02*V(F1113) -4.6985242220534921e+01*V(F1114) +2.7653702024373757e+01*V(F1115) -6.1059420125347451e+01*V(F1116) +9.6775446301112538e+01*V(F1117) -1.1385529747782952e+02*V(F1118) +9.6775446302061226e+01*V(F1119) -6.1059420126578019e+01*V(F1120) +2.7653702025263730e+01*V(F1121) +6.6675892952422684e+00*V(F1122) -1.4746178309926458e+01*V(F1123) +2.3379971184283324e+01*V(F1124) -2.7484000081754814e+01*V(F1125) +2.3379971184513391e+01*V(F1126) -1.4746178310223728e+01*V(F1127) +6.6675892954500720e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1097)));
	I(F1098)<+( -1.4601918897194746e-25*V(reduced_0) +1.0858928318855999e-25*V(reduced_1) +1.6813115341490037e+00*V(F841) +6.8714266225736687e+00*V(F850) -1.1648536786744307e+01*V(F859) +1.7267664106091452e+01*V(F868) -2.3570232482045782e+01*V(F877) +1.7267664106095221e+01*V(F886) -1.1648536786748545e+01*V(F895) +6.8714266225765739e+00*V(F904) +1.6813115341533533e+00*V(F913) +1.0277850647773517e+00*V(F1001) +4.2038941219080428e+00*V(F1009) -7.1273928865787033e+00*V(F1017) +1.0565964300085716e+01*V(F1025) -1.4421312452092721e+01*V(F1033) +1.0565964300082259e+01*V(F1041) -7.1273928865757155e+00*V(F1049) +4.2038941218990304e+00*V(F1057) +1.0277850647878515e+00*V(F1065) -4.5736305629758824e+00*V(F1066) +1.0825242181595975e+01*V(F1067) -1.8271548080385735e+01*V(F1068) +2.3379971184449310e+01*V(F1069) -2.2127952399562620e+01*V(F1070) +1.5078657113386935e+01*V(F1071) -6.9827935376860060e+00*V(F1072) -1.8966315694096874e+01*V(F1073) +4.4823014116096118e+01*V(F1074) -7.5639484265622428e+01*V(F1075) +9.6775446302018409e+01*V(F1076) -9.1694860810352083e+01*V(F1077) +6.2430925469023386e+01*V(F1078) -2.8962738692239476e+01*V(F1079) +3.2224160494689563e+01*V(F1080) -7.6137569845285284e+01*V(F1081) +1.2847916438396393e+02*V(F1082) -1.6437711966152506e+02*V(F1083) +1.5577401379360919e+02*V(F1084) -1.0604585477770708e+02*V(F1085) +4.9209821127129381e+01*V(F1086) -4.7800626490330252e+01*V(F1087) +1.1293305571556409e+02*V(F1088) -1.9056830401339155e+02*V(F1089) +2.4381306070251804e+02*V(F1090) -2.3106413709999026e+02*V(F1091) +1.5729487344103222e+02*V(F1092) -7.2997465198816471e+01*V(F1093) +6.5154614308284721e+01*V(F1094) -1.5395597543957572e+02*V(F1095) +2.5979746079694490e+02*V(F1096) -3.3238870031257130e+02*V(F1097) +3.1497420040633222e+02*V(F1098) -2.1443348091724860e+02*V(F1099) +9.9497184149229398e+01*V(F1100) -4.7800626490336867e+01*V(F1101) +1.1293305571558919e+02*V(F1102) -1.9056830401343547e+02*V(F1103) +2.4381306070257475e+02*V(F1104) -2.3106413710004426e+02*V(F1105) +1.5729487344106883e+02*V(F1106) -7.2997465198832572e+01*V(F1107) +3.2224160494697600e+01*V(F1108) -7.6137569845313294e+01*V(F1109) +1.2847916438401282e+02*V(F1110) -1.6437711966158801e+02*V(F1111) +1.5577401379366933e+02*V(F1112) -1.0604585477774788e+02*V(F1113) +4.9209821127147571e+01*V(F1114) -1.8966315694096789e+01*V(F1115) +4.4823014116113541e+01*V(F1116) -7.5639484265654929e+01*V(F1117) +9.6775446302060942e+01*V(F1118) -9.1694860810393081e+01*V(F1119) +6.2430925469051211e+01*V(F1120) -2.8962738692251001e+01*V(F1121) -4.5736305629945289e+00*V(F1122) +1.0825242181627349e+01*V(F1123) -1.8271548080436471e+01*V(F1124) +2.3379971184513625e+01*V(F1125) -2.2127952399622902e+01*V(F1126) +1.5078657113427790e+01*V(F1127) -6.9827935377056125e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1098)));
	I(F1099)<+( +1.3019637422344534e-26*V(reduced_0) -9.7253948366389736e-27*V(reduced_1) -1.3324279959513385e+00*V(F841) -5.4448310002094313e+00*V(F850) +9.2299605511803673e+00*V(F859) -1.3682308360179464e+01*V(F868) +1.8676495345696857e+01*V(F877) -1.3682308360182438e+01*V(F886) +9.2299605511837033e+00*V(F895) -5.4448310002117095e+00*V(F904) -1.3324279959547967e+00*V(F913) -4.5950216691414647e-01*V(F1001) -1.8813435065596729e+00*V(F1009) +3.1901705361101169e+00*V(F1017) -4.7294675860178206e+00*V(F1025) +6.4545414538952137e+00*V(F1033) -4.7294675860164821e+00*V(F1041) +3.1901705361089845e+00*V(F1049) -1.8813435065560218e+00*V(F1057) -4.5950216691857532e-01*V(F1065) +2.2151044657507040e+00*V(F1066) -5.8213095598634581e+00*V(F1067) +1.0825242181724475e+01*V(F1068) -1.4746178310182920e+01*V(F1069) +1.5078657113385852e+01*V(F1070) -1.1523014944741460e+01*V(F1071) +5.7601541179059366e+00*V(F1072) +9.1842575663525086e+00*V(F1073) -2.4105992583579503e+01*V(F1074) +4.4823014116622787e+01*V(F1075) -6.1059420126551373e+01*V(F1076) +6.2430925469024146e+01*V(F1077) -4.7812625190805235e+01*V(F1078) +2.3880046024273405e+01*V(F1079) -1.5603846984585843e+01*V(F1080) +4.0947673289697136e+01*V(F1081) -7.6137569846178906e+01*V(F1082) +1.0371751972928834e+02*V(F1083) -1.0604585477770723e+02*V(F1084) +8.1241906249282010e+01*V(F1085) -4.0570964507468148e+01*V(F1086) +2.3146236691204905e+01*V(F1087) -6.0736974833675895e+01*V(F1088) +1.1293305571688889e+02*V(F1089) -1.5384189992691043e+02*V(F1090) +1.5729487344103214e+02*V(F1091) -1.2051570022530643e+02*V(F1092) +6.0181336063392081e+01*V(F1093) -3.1549970934697189e+01*V(F1094) +8.2798917099588238e+01*V(F1095) -1.5395597544138391e+02*V(F1096) +2.0972449506538217e+02*V(F1097) -2.1443348091724860e+02*V(F1098) +1.6425952190302147e+02*V(F1099) -8.2032345353708862e+01*V(F1100) +2.3146236691208440e+01*V(F1101) -6.0736974833689551e+01*V(F1102) +1.1293305571691518e+02*V(F1103) -1.5384189992694647e+02*V(F1104) +1.5729487344106906e+02*V(F1105) -1.2051570022533475e+02*V(F1106) +6.0181336063405325e+01*V(F1107) -1.5603846984590044e+01*V(F1108) +4.0947673289712398e+01*V(F1109) -7.6137569846208024e+01*V(F1110) +1.0371751972932834e+02*V(F1111) -1.0604585477774819e+02*V(F1112) +8.1241906249313544e+01*V(F1113) -4.0570964507483119e+01*V(F1114) +9.1842575663530699e+00*V(F1115) -2.4105992583589217e+01*V(F1116) +4.4823014116642348e+01*V(F1117) -6.1059420126578530e+01*V(F1118) +6.2430925469052006e+01*V(F1119) -4.7812625190826751e+01*V(F1120) +2.3880046024282926e+01*V(F1121) +2.2151044657593051e+00*V(F1122) -5.8213095598801345e+00*V(F1123) +1.0825242181754414e+01*V(F1124) -1.4746178310223380e+01*V(F1125) +1.5078657113427260e+01*V(F1126) -1.1523014944772813e+01*V(F1127) +5.7601541179220384e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1099)));
	I(F1100)<+( -8.3301505783888443e-26*V(reduced_0) +6.2495967538544223e-26*V(reduced_1) +1.1117172853418182e+00*V(F841) +4.5484537333243367e+00*V(F850) -7.7118989017323800e+00*V(F859) +1.1432607970553189e+01*V(F868) -1.5603755080920031e+01*V(F877) +1.1432607970555621e+01*V(F886) -7.7118989017351209e+00*V(F895) +4.5484537333261335e+00*V(F904) +1.1117172853447930e+00*V(F913) +1.3280266943863225e-01*V(F1001) +5.4502753184169739e-01*V(F1009) -9.2453612384193795e-01*V(F1017) +1.3707863256519193e+00*V(F1025) -1.8703438394339067e+00*V(F1033) +1.3707863256516524e+00*V(F1041) -9.2453612384172623e-01*V(F1049) +5.4502753184085795e-01*V(F1057) +1.3280266943976277e-01*V(F1065) -7.3270606768475510e-01*V(F1066) +2.2151044657877783e+00*V(F1067) -4.5736305630970131e+00*V(F1068) +6.6675892954299893e+00*V(F1069) -6.9827935376844401e+00*V(F1070) +5.7601541179044888e+00*V(F1071) -3.5774577276752870e+00*V(F1072) -3.0397397932148387e+00*V(F1073) +9.1842575665030868e+00*V(F1074) -1.8966315694590005e+01*V(F1075) +2.7653702025253331e+01*V(F1076) -2.8962738692240261e+01*V(F1077) +2.3880046024274176e+01*V(F1078) -1.4931715508611713e+01*V(F1079) +5.1649159703409842e+00*V(F1080) -1.5603846984841544e+01*V(F1081) +3.2224160495526768e+01*V(F1082) -4.6985242220517328e+01*V(F1083) +4.9209821127129182e+01*V(F1084) -4.0570964507468020e+01*V(F1085) +2.5394317349199824e+01*V(F1086) -7.6616730748890491e+00*V(F1087) +2.3146236691583876e+01*V(F1088) -4.7800626491571158e+01*V(F1089) +6.9697352994298583e+01*V(F1090) -7.2997465198815661e+01*V(F1091) +6.0181336063391420e+01*V(F1092) -3.7680409776699172e+01*V(F1093) +1.0442808341139559e+01*V(F1094) -3.1549970935215516e+01*V(F1095) +6.5154614309981056e+01*V(F1096) -9.4999607920090199e+01*V(F1097) +9.9497184149229398e+01*V(F1098) -8.2032345353708862e+01*V(F1099) +5.1328158653817653e+01*V(F1100) -7.6616730748904471e+00*V(F1101) +2.3146236691589426e+01*V(F1102) -4.7800626491582918e+01*V(F1103) +6.9697352994315906e+01*V(F1104) -7.2997465198833879e+01*V(F1105) +6.0181336063406413e+01*V(F1106) -3.7680409776708203e+01*V(F1107) +5.1649159703425926e+00*V(F1108) -1.5603846984847662e+01*V(F1109) +3.2224160495539699e+01*V(F1110) -4.6985242220536378e+01*V(F1111) +4.9209821127149205e+01*V(F1112) -4.0570964507484476e+01*V(F1113) +2.5394317349209910e+01*V(F1114) -3.0397397932154218e+00*V(F1115) +9.1842575665072825e+00*V(F1116) -1.8966315694599235e+01*V(F1117) +2.7653702025267048e+01*V(F1118) -2.8962738692254746e+01*V(F1119) +2.3880046024286059e+01*V(F1120) -1.4931715508618627e+01*V(F1121) -7.3270606768734303e-01*V(F1122) +2.2151044657938743e+00*V(F1123) -4.5736305631092398e+00*V(F1124) +6.6675892954476685e+00*V(F1125) -6.9827935377029124e+00*V(F1126) +5.7601541179197842e+00*V(F1127) -3.5774577276849788e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1100)));
	I(F1101)<+( +1.8294941842867360e-25*V(reduced_0) -1.3343024447204183e-25*V(reduced_1) -8.1071093004624256e-02*V(F841) -3.6619554294669021e-01*V(F850) +6.7588006180510440e-01*V(F859) -1.0966914735672475e+00*V(F868) +1.3707863256849637e+00*V(F877) -1.5831459538295798e+00*V(F886) +9.3082249721064692e-01*V(F895) -5.7565653919368398e-01*V(F904) -1.4820116388957913e-01*V(F913) -6.7873832728716721e-01*V(F1001) -3.0559347097814089e+00*V(F1009) +5.6377179625046656e+00*V(F1017) -9.1470727936158802e+00*V(F1025) +1.1432607970031805e+01*V(F1033) -1.3208964158746213e+01*V(F1041) +7.7640863123503792e+00*V(F1049) -4.8041279220615376e+00*V(F1057) -1.2405482244986872e+00*V(F1065) +2.1825526913247422e+00*V(F1066) -3.5150593884011574e+00*V(F1067) +4.2610836446537252e+00*V(F1068) -4.0687467160301720e+00*V(F1069) +2.7909701919023542e+00*V(F1070) -1.3517332011919940e+00*V(F1071) +4.4711280154492866e-01*V(F1072) +1.0034175411125496e+01*V(F1073) -1.6046351536018612e+01*V(F1074) +1.9461798707222314e+01*V(F1075) -1.8582166851473858e+01*V(F1076) +1.2744576020086379e+01*V(F1077) -6.1714286458848155e+00*V(F1078) +2.0425879859793348e+00*V(F1079) -1.8565318031051607e+01*V(F1080) +2.9660139087444140e+01*V(F1081) -3.5975779308206604e+01*V(F1082) +3.4349452799043732e+01*V(F1083) -2.3558074648237529e+01*V(F1084) +1.1407478719370326e+01*V(F1085) -3.7759127236854755e+00*V(F1086) +3.0137781265515223e+01*V(F1087) -4.8139862590116941e+01*V(F1088) +5.8391200827766866e+01*V(F1089) -5.5751471251679277e+01*V(F1090) +3.8236193486487743e+01*V(F1091) -1.8514953256585176e+01*V(F1092) +6.1286057579696500e+00*V(F1093) -3.7680409775306160e+01*V(F1094) +6.0181336061258349e+01*V(F1095) -7.2997465196250062e+01*V(F1096) +6.9697352992097279e+01*V(F1097) -4.7800626490336867e+01*V(F1098) +2.3146236691208440e+01*V(F1099) -7.6616730748904471e+00*V(F1100) +4.3424891596196616e+01*V(F1101) -6.9415169703533039e+01*V(F1102) +8.4192591495552705e+01*V(F1103) -8.0386971340177681e+01*V(F1104) +5.5132904936039921e+01*V(F1105) -2.6697265831235370e+01*V(F1106) +8.8364446104740129e+00*V(F1107) -2.5571411588440402e+01*V(F1108) +4.0851083021710899e+01*V(F1109) -4.9549830407581936e+01*V(F1110) +4.7309852068067507e+01*V(F1111) -3.2446741709999003e+01*V(F1112) +1.5711600394482240e+01*V(F1113) -5.2006141185279571e+00*V(F1114) +1.5769701776388604e+01*V(F1115) -2.5220946527469241e+01*V(F1116) +3.0588977274615029e+01*V(F1117) -2.9206446502364773e+01*V(F1118) +2.0031279126765494e+01*V(F1119) -9.6999628052883722e+00*V(F1120) +3.2104161428208520e+00*V(F1121) +3.9935572664660803e+00*V(F1122) -6.4292883031833590e+00*V(F1123) +7.7940291484129451e+00*V(F1124) -7.4421970545256482e+00*V(F1125) +5.1049583447649693e+00*V(F1126) -2.4724296790924289e+00*V(F1127) +8.1783268484269855e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1101)));
	I(F1102)<+( -2.9087350272284447e-26*V(reduced_0) +2.1317627895944806e-26*V(reduced_1) +2.8053321165761907e-01*V(F841) +1.2640135007611193e+00*V(F850) -2.3321516331464340e+00*V(F859) +3.7839373858450482e+00*V(F868) -4.7294675861952262e+00*V(F877) +5.4638115937504557e+00*V(F886) -3.2117827965436696e+00*V(F895) +1.9870900058331677e+00*V(F904) +5.1275837742346764e-01*V(F913) +8.1352507506574900e-01*V(F1001) +3.6581291933767219e+00*V(F1009) -6.7474610839923477e+00*V(F1017) +1.0947247527201879e+01*V(F1025) -1.3682308359497450e+01*V(F1033) +1.5810691769469706e+01*V(F1041) -9.2923028789092292e+00*V(F1049) +5.7509218783077891e+00*V(F1057) +1.4868015713619123e+00*V(F1065) -3.5150593883994765e+00*V(F1066) +7.0315467697366909e+00*V(F1067) -9.2019944042545614e+00*V(F1068) +8.9990663594741598e+00*V(F1069) -6.6062644258227632e+00*V(F1070) +3.5525281151602321e+00*V(F1071) -1.3517332012144045e+00*V(F1072) -1.6046351536021380e+01*V(F1073) +3.2128295822842254e+01*V(F1074) -4.1950289688214852e+01*V(F1075) +4.1028746423868498e+01*V(F1076) -3.0118721075443791e+01*V(F1077) +1.6197982285735904e+01*V(F1078) -6.1714286459866559e+00*V(F1079) +2.9660139087446698e+01*V(F1080) -5.9393508862396310e+01*V(F1081) +7.7526468645316470e+01*V(F1082) -7.5824320440485664e+01*V(F1083) +5.5661561835310316e+01*V(F1084) -2.9935445037448467e+01*V(F1085) +1.1407478719557997e+01*V(F1086) -4.8139862590120927e+01*V(F1087) +9.6400783863047550e+01*V(F1088) -1.2582494325723711e+02*V(F1089) +1.2306263882622926e+02*V(F1090) -9.0338489882895288e+01*V(F1091) +4.8585227421809194e+01*V(F1092) -1.8514953256889701e+01*V(F1093) +6.0181336061265355e+01*V(F1094) -1.2051570022183454e+02*V(F1095) +1.5729487343706199e+02*V(F1096) -1.5384189992385697e+02*V(F1097) +1.1293305571558919e+02*V(F1098) -6.0736974833689551e+01*V(F1099) +2.3146236691589426e+01*V(F1100) -6.9415169703533039e+01*V(F1101) +1.3899166209022621e+02*V(F1102) -1.8145899601761590e+02*V(F1103) +1.7747369833202677e+02*V(F1104) -1.3028117897370140e+02*V(F1105) +7.0066202426526232e+01*V(F1106) -2.6697265831674127e+01*V(F1107) +4.0851083021699878e+01*V(F1108) -8.1803557358890629e+01*V(F1109) +1.0677661740735418e+02*V(F1110) -1.0443232680992028e+02*V(F1111) +7.6662281982493866e+01*V(F1112) -4.1229909416412667e+01*V(F1113) +1.5711600394738291e+01*V(F1114) -2.5220946527448895e+01*V(F1115) +5.0497190279128731e+01*V(F1116) -6.5936880553348928e+01*V(F1117) +6.4488332271912341e+01*V(F1118) -4.7340143398559114e+01*V(F1119) +2.5459704356667405e+01*V(F1120) -9.6999628054444695e+00*V(F1121) -6.4292883031984713e+00*V(F1122) +1.2861811619295233e+01*V(F1123) -1.6829864738805398e+01*V(F1124) +1.6458798722082012e+01*V(F1125) -1.2082480053551174e+01*V(F1126) +6.4974051064899978e+00*V(F1127) -2.4724296791361824e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1102)));
	I(F1103)<+( +3.3184869917700745e-25*V(reduced_0) -2.4436553071023836e-25*V(reduced_1) -6.2750135953298458e-01*V(F841) -2.8244297484494005e+00*V(F850) +5.2104158117223935e+00*V(F859) -8.4537216544908027e+00*V(F868) +1.0565964300550403e+01*V(F877) -1.2208098291897235e+01*V(F886) +7.1756042116933463e+00*V(F895) -4.4402054812446057e+00*V(F904) -1.1468835379805686e+00*V(F913) -1.0265338666617669e+00*V(F1001) -4.6165991725241398e+00*V(F1009) +8.5155378013736840e+00*V(F1017) -1.3815868647807683e+01*V(F1025) +1.7267664105246840e+01*V(F1033) -1.9953432333192040e+01*V(F1041) +1.1727231375261505e+01*V(F1049) -7.2577119258397724e+00*V(F1057) -1.8761111110896991e+00*V(F1065) +4.2610836446517375e+00*V(F1066) -9.2019944042536945e+00*V(F1067) +1.3503521782523947e+01*V(F1068) -1.4268145479518639e+01*V(F1069) +1.1150568036018202e+01*V(F1070) -6.6062644259010854e+00*V(F1071) +2.7909701919757310e+00*V(F1072) +1.9461798707225764e+01*V(F1073) -4.1950289688215896e+01*V(F1074) +6.1614660134038473e+01*V(F1075) -6.5027813287305165e+01*V(F1076) +5.0825665691940280e+01*V(F1077) -3.0118721075798028e+01*V(F1078) +1.2744576020419421e+01*V(F1079) -3.5975779308209873e+01*V(F1080) +7.7526468645317223e+01*V(F1081) -1.1388127499457988e+02*V(F1082) +1.2017035752889905e+02*V(F1083) -9.3926650033439543e+01*V(F1084) +5.5661561835963973e+01*V(F1085) -2.3558074648851438e+01*V(F1086) +5.8391200827772025e+01*V(F1087) -1.2582494325723815e+02*V(F1088) +1.8483268250134850e+02*V(F1089) -1.9503431283975610e+02*V(F1090) +1.5244173463443153e+02*V(F1091) -9.0338489883955944e+01*V(F1092) +3.8236193487483931e+01*V(F1093) -7.2997465196259142e+01*V(F1094) +1.5729487343706381e+02*V(F1095) -2.3106413709593039e+02*V(F1096) +2.4381306070019099e+02*V(F1097) -1.9056830401343547e+02*V(F1098) +1.1293305571691518e+02*V(F1099) -4.7800626491582918e+01*V(F1100) +8.4192591495552705e+01*V(F1101) -1.8145899601761590e+02*V(F1102) +2.6653243326816693e+02*V(F1103) -2.8127788228153224e+02*V(F1104) +2.1984809044524300e+02*V(F1105) -1.3028117897523211e+02*V(F1106) +5.5132904937475850e+01*V(F1107) -4.9549830407567619e+01*V(F1108) +1.0677661740735132e+02*V(F1109) -1.5684881126081228e+02*V(F1110) +1.6550939018410963e+02*V(F1111) -1.2936431981562066e+02*V(F1112) +7.6662281983392774e+01*V(F1113) -3.2446741710838332e+01*V(F1114) +3.0588977274588594e+01*V(F1115) -6.5936880553343713e+01*V(F1116) +9.6843852485433473e+01*V(F1117) -1.0221021480359330e+02*V(F1118) +7.9887247058119414e+01*V(F1119) -4.7340143399113749e+01*V(F1120) +2.0031279127278804e+01*V(F1121) +7.7940291484325561e+00*V(F1122) -1.6829864738809324e+01*V(F1123) +2.4698252887330824e+01*V(F1124) -2.6095144505539931e+01*V(F1125) +2.0393514600848402e+01*V(F1126) -1.2082480053695940e+01*V(F1127) +5.1049583449062412e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1103)));
	I(F1104)<+( -1.4477713820421836e-25*V(reduced_0) +1.0710755328164958e-25*V(reduced_1) +9.5697020405692645e-01*V(F841) +4.3050953675416403e+00*V(F850) -7.9413029657511567e+00*V(F859) +1.2884315937185999e+01*V(F868) -1.6103448991582674e+01*V(F877) +1.8607424402503572e+01*V(F886) -1.0936444836937174e+01*V(F895) +6.7679694597943012e+00*V(F904) +1.7490041311174720e+00*V(F913) +9.5697020401102084e-01*V(F1001) +4.3050953673398515e+00*V(F1009) -7.9413029653764236e+00*V(F1017) +1.2884315936577698e+01*V(F1025) -1.6103448990823793e+01*V(F1033) +1.8607424401621881e+01*V(F1041) -1.0936444836409880e+01*V(F1049) +6.7679694594582456e+00*V(F1057) +1.7490041310473008e+00*V(F1065) -4.0687467160283592e+00*V(F1066) +8.9990663594734368e+00*V(F1067) -1.4268145479518031e+01*V(F1068) +1.6772220343662969e+01*V(F1069) -1.4268145479659514e+01*V(F1070) +8.9990663596566947e+00*V(F1071) -4.0687467161608879e+00*V(F1072) -1.8582166851477020e+01*V(F1073) +4.1028746423869528e+01*V(F1074) -6.5027813287305776e+01*V(F1075) +7.6505195138634420e+01*V(F1076) -6.5027813287941910e+01*V(F1077) +4.1028746424693871e+01*V(F1078) -1.8582166852066820e+01*V(F1079) +3.4349452799046773e+01*V(F1080) -7.5824320440486488e+01*V(F1081) +1.2017035752889944e+02*V(F1082) -1.4139702041250214e+02*V(F1083) +1.2017035753007430e+02*V(F1084) -7.5824320442008769e+01*V(F1085) +3.4349452800136937e+01*V(F1086) -5.5751471251684080e+01*V(F1087) +1.2306263882623054e+02*V(F1088) -1.9503431283975652e+02*V(F1089) +2.2948972827849948e+02*V(F1090) -1.9503431284166308e+02*V(F1091) +1.2306263882870070e+02*V(F1092) -5.5751471253453161e+01*V(F1093) +6.9697352992105735e+01*V(F1094) -1.5384189992385910e+02*V(F1095) +2.4381306070019167e+02*V(F1096) -2.8688967109569450e+02*V(F1097) +2.4381306070257475e+02*V(F1098) -1.5384189992694647e+02*V(F1099) +6.9697352994315906e+01*V(F1100) -8.0386971340177681e+01*V(F1101) +1.7747369833202677e+02*V(F1102) -2.8127788228153224e+02*V(F1103) +3.3093975575551985e+02*V(F1104) -2.8127788228428477e+02*V(F1105) +1.7747369833559355e+02*V(F1106) -8.0386971342735038e+01*V(F1107) +4.7309852068054155e+01*V(F1108) -1.0443232680991694e+02*V(F1109) +1.6550939018410861e+02*V(F1110) -1.9474583981449842e+02*V(F1111) +1.6550939018572768e+02*V(F1112) -1.0443232681201566e+02*V(F1113) +4.7309852069563263e+01*V(F1114) -2.9206446502340132e+01*V(F1115) +6.4488332271906174e+01*V(F1116) -1.0221021480359147e+02*V(F1117) +1.2024883014299910e+02*V(F1118) -1.0221021480459351e+02*V(F1119) +6.4488332273206055e+01*V(F1120) -2.9206446503280667e+01*V(F1121) -7.4421970545439251e+00*V(F1122) +1.6458798722086623e+01*V(F1123) -2.6095144505541342e+01*V(F1124) +3.0676262008485715e+01*V(F1125) -2.6095144505798103e+01*V(F1126) +1.6458798722418397e+01*V(F1127) -7.4421970547759360e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1104)));
	I(F1105)<+( +3.3757017419854115e-25*V(reduced_0) -2.5087714736161522e-25*V(reduced_1) -1.0265338667130777e+00*V(F841) -4.6165991727497948e+00*V(F850) +8.5155378017926946e+00*V(F859) -1.3815868648487839e+01*V(F868) +1.7267664106095406e+01*V(F877) -1.9953432334177808e+01*V(F886) +1.1727231375850812e+01*V(F895) -7.2577119262151193e+00*V(F904) -1.8761111111684579e+00*V(F913) -6.2750135950505859e-01*V(F1001) -2.8244297483267751e+00*V(F1009) +5.2104158114946175e+00*V(F1017) -8.4537216541210469e+00*V(F1025) +1.0565964300089153e+01*V(F1033) -1.2208098291361225e+01*V(F1041) +7.1756042113725824e+00*V(F1049) -4.4402054810399463e+00*V(F1057) -1.1468835379381965e+00*V(F1065) +2.7909701919012004e+00*V(F1066) -6.6062644258222605e+00*V(F1067) +1.1150568036017779e+01*V(F1068) -1.4268145479658946e+01*V(F1069) +1.3503521782767161e+01*V(F1070) -9.2019944044913888e+00*V(F1071) +4.2610836448060203e+00*V(F1072) +1.2744576020088397e+01*V(F1073) -3.0118721075444483e+01*V(F1074) +5.0825665691940706e+01*V(F1075) -6.5027813287942365e+01*V(F1076) +6.1614660135137434e+01*V(F1077) -4.1950289689285327e+01*V(F1078) +1.9461798707912855e+01*V(F1079) -2.3558074648239465e+01*V(F1080) +5.5661561835310891e+01*V(F1081) -9.3926650033439856e+01*V(F1082) +1.2017035753007445e+02*V(F1083) -1.1388127499660828e+02*V(F1084) +7.7526468647292049e+01*V(F1085) -3.5975779309479826e+01*V(F1086) +3.8236193486490805e+01*V(F1087) -9.0338489882896155e+01*V(F1088) +1.5244173463443192e+02*V(F1089) -1.9503431284166319e+02*V(F1090) +1.8483268250463973e+02*V(F1091) -1.2582494326044271e+02*V(F1092) +5.8391200829832847e+01*V(F1093) -4.7800626490342253e+01*V(F1094) +1.1293305571559068e+02*V(F1095) -1.9056830401343603e+02*V(F1096) +2.4381306070257492e+02*V(F1097) -2.3106413710004426e+02*V(F1098) +1.5729487344106906e+02*V(F1099) -7.2997465198833879e+01*V(F1100) +5.5132904936039921e+01*V(F1101) -1.3028117897370140e+02*V(F1102) +2.1984809044524300e+02*V(F1103) -2.8127788228428477e+02*V(F1104) +2.6653243327291796e+02*V(F1105) -1.8145899602224273e+02*V(F1106) +8.4192591498531513e+01*V(F1107) -3.2446741709990505e+01*V(F1108) +7.6662281982491521e+01*V(F1109) -1.2936431981561972e+02*V(F1110) +1.6550939018572748e+02*V(F1111) -1.5684881126360597e+02*V(F1112) +1.0677661741007297e+02*V(F1113) -4.9549830409324869e+01*V(F1114) +2.0031279126749798e+01*V(F1115) -4.7340143398554808e+01*V(F1116) +7.9887247058117794e+01*V(F1117) -1.0221021480459324e+02*V(F1118) +9.6843852487161243e+01*V(F1119) -6.5936880555028424e+01*V(F1120) +3.0588977275683092e+01*V(F1121) +5.1049583447766071e+00*V(F1122) -1.2082480053554377e+01*V(F1123) +2.0393514600849674e+01*V(F1124) -2.6095144505798373e+01*V(F1125) +2.4698252887775475e+01*V(F1126) -1.6829864739240779e+01*V(F1127) +7.7940291487035820e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1105)));
	I(F1106)<+( -3.0099074511924482e-26*V(reduced_0) +2.2469072302379812e-26*V(reduced_1) +8.1352507510717020e-01*V(F841) +3.6581291935589291e+00*V(F850) -6.7474610843306575e+00*V(F859) +1.0947247527751033e+01*V(F868) -1.3682308360182597e+01*V(F877) +1.5810691770265541e+01*V(F886) -9.2923028793848381e+00*V(F895) +5.7509218786105398e+00*V(F904) +1.4868015714257139e+00*V(F913) +2.8053321164694645e-01*V(F1001) +1.2640135007143745e+00*V(F1009) -2.3321516330595564e+00*V(F1017) +3.7839373857040171e+00*V(F1025) -4.7294675860193243e+00*V(F1033) +5.4638115935459304e+00*V(F1041) -3.2117827964210917e+00*V(F1049) +1.9870900057547551e+00*V(F1057) +5.1275837740755703e-01*V(F1065) -1.3517332011914962e+00*V(F1066) +3.5525281151599395e+00*V(F1067) -6.6062644259007124e+00*V(F1068) +8.9990663596561724e+00*V(F1069) -9.2019944044907049e+00*V(F1070) +7.0315467699437892e+00*V(F1071) -3.5150593885278263e+00*V(F1072) -6.1714286458856682e+00*V(F1073) +1.6197982285736263e+01*V(F1074) -3.0118721075798337e+01*V(F1075) +4.1028746424694241e+01*V(F1076) -4.1950289689285803e+01*V(F1077) +3.2128295823777385e+01*V(F1078) -1.6046351536592717e+01*V(F1079) +1.1407478719371126e+01*V(F1080) -2.9935445037448698e+01*V(F1081) +5.5661561835964065e+01*V(F1082) -7.5824320442008826e+01*V(F1083) +7.7526468647292134e+01*V(F1084) -5.9393508864122154e+01*V(F1085) +2.9660139088502703e+01*V(F1086) -1.8514953256586431e+01*V(F1087) +4.8585227421809535e+01*V(F1088) -9.0338489883956044e+01*V(F1089) +1.2306263882870059e+02*V(F1090) -1.2582494326044261e+02*V(F1091) +9.6400783865847899e+01*V(F1092) -4.8139862591834572e+01*V(F1093) +2.3146236691210660e+01*V(F1094) -6.0736974833690120e+01*V(F1095) +1.1293305571691528e+02*V(F1096) -1.5384189992694630e+02*V(F1097) +1.5729487344106883e+02*V(F1098) -1.2051570022533475e+02*V(F1099) +6.0181336063406413e+01*V(F1100) -2.6697265831235370e+01*V(F1101) +7.0066202426526232e+01*V(F1102) -1.3028117897523211e+02*V(F1103) +1.7747369833559355e+02*V(F1104) -1.8145899602224273e+02*V(F1105) +1.3899166209426897e+02*V(F1106) -6.9415169706009820e+01*V(F1107) +1.5711600394478742e+01*V(F1108) -4.1229909416411743e+01*V(F1109) +7.6662281983392589e+01*V(F1110) -1.0443232681201596e+02*V(F1111) +1.0677661741007338e+02*V(F1112) -8.1803557361267593e+01*V(F1113) +4.0851083023160498e+01*V(F1114) -9.6999628052819062e+00*V(F1115) +2.5459704356665743e+01*V(F1116) -4.7340143399113444e+01*V(F1117) +6.4488332273206638e+01*V(F1118) -6.5936880555029333e+01*V(F1119) +5.0497190280598915e+01*V(F1120) -2.5220946528358091e+01*V(F1121) -2.4724296790972238e+00*V(F1122) +6.4974051064912501e+00*V(F1123) -1.2082480053696200e+01*V(F1124) +1.6458798722418017e+01*V(F1125) -1.6829864739240197e+01*V(F1126) +1.2861811619673835e+01*V(F1127) -6.4292883034244488e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1106)));
	I(F1107)<+( +1.9257824224500622e-25*V(reduced_0) -1.4438881883625799e-25*V(reduced_1) -6.7873832731882855e-01*V(F841) -3.0559347099207810e+00*V(F850) +5.6377179627633760e+00*V(F859) -9.1470727940358358e+00*V(F868) +1.1432607970555825e+01*V(F877) -1.3208964159354633e+01*V(F886) +7.7640863127135828e+00*V(F895) -4.8041279222922748e+00*V(F904) -1.2405482245480273e+00*V(F913) -8.1071093002620970e-02*V(F1001) -3.6619554293804013e-01*V(F1009) +6.7588006178897897e-01*V(F1017) -1.0966914735410651e+00*V(F1025) +1.3707863256523360e+00*V(F1033) -1.5831459537915402e+00*V(F1041) +9.3082249718767684e-01*V(F1049) -5.7565653917880133e-01*V(F1057) -1.4820116388685858e-01*V(F1065) +4.4711280154476035e-01*V(F1066) -1.3517332012141370e+00*V(F1067) +2.7909701919751631e+00*V(F1068) -4.0687467161600059e+00*V(F1069) +4.2610836448050362e+00*V(F1070) -3.5150593885269181e+00*V(F1071) +2.1825526914081443e+00*V(F1072) +2.0425879859795635e+00*V(F1073) -6.1714286459868308e+00*V(F1074) +1.2744576020419712e+01*V(F1075) -1.8582166852067228e+01*V(F1076) +1.9461798707913339e+01*V(F1077) -1.6046351536593182e+01*V(F1078) +1.0034175411500382e+01*V(F1079) -3.7759127236856598e+00*V(F1080) +1.1407478719558013e+01*V(F1081) -2.3558074648851342e+01*V(F1082) +3.4349452800136767e+01*V(F1083) -3.5975779309479627e+01*V(F1084) +2.9660139088502543e+01*V(F1085) -1.8565318031743011e+01*V(F1086) +6.1286057579699218e+00*V(F1087) -1.8514953256889644e+01*V(F1088) +3.8236193487483590e+01*V(F1089) -5.5751471253452571e+01*V(F1090) +5.8391200829832165e+01*V(F1091) -4.8139862591834010e+01*V(F1092) +3.0137781266636992e+01*V(F1093) -7.6616730748909188e+00*V(F1094) +2.3146236691589273e+01*V(F1095) -4.7800626491582243e+01*V(F1096) +6.9697352994314741e+01*V(F1097) -7.2997465198832572e+01*V(F1098) +6.0181336063405325e+01*V(F1099) -3.7680409776708203e+01*V(F1100) +8.8364446104740129e+00*V(F1101) -2.6697265831674127e+01*V(F1102) +5.5132904937475850e+01*V(F1103) -8.0386971342735038e+01*V(F1104) +8.4192591498531513e+01*V(F1105) -6.9415169706009820e+01*V(F1106) +4.3424891597816874e+01*V(F1107) -5.2006141185272190e+00*V(F1108) +1.5711600394738536e+01*V(F1109) -3.2446741710839440e+01*V(F1110) +4.7309852069565189e+01*V(F1111) -4.9549830409327022e+01*V(F1112) +4.0851083023162303e+01*V(F1113) -2.5571411589392625e+01*V(F1114) +3.2104161428194975e+00*V(F1115) -9.6999628054449740e+00*V(F1116) +2.0031279127280957e+01*V(F1117) -2.9206446503284376e+01*V(F1118) +3.0588977275687252e+01*V(F1119) -2.5220946528361580e+01*V(F1120) +1.5769701776978017e+01*V(F1121) +8.1783268484370930e-01*V(F1122) -2.4724296791358391e+00*V(F1123) +5.1049583449047118e+00*V(F1124) -7.4421970547732919e+00*V(F1125) +7.7940291487006093e+00*V(F1126) -6.4292883034219672e+00*V(F1127) +3.9935572666185450e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1107)));
	I(F1108)<+( -1.6174872587933280e-26*V(reduced_0) +1.1788764701426860e-26*V(reduced_1) +3.1007351448776643e-02*V(F841) +1.7307966461488677e-01*V(F850) -3.6982558640320767e-01*V(F859) +6.7588006180524685e-01*V(F868) -9.2453612386434847e-01*V(F877) +9.3082249721057186e-01*V(F886) -1.0012390694149129e+00*V(F895) +4.4254745870529294e-01*V(F904) +1.1949153117361441e-01*V(F913) +2.5966917119090205e-01*V(F1001) +1.4443079512183430e+00*V(F1009) -3.0849355749851055e+00*V(F1017) +5.6377179625073204e+00*V(F1025) -7.7118989013838455e+00*V(F1033) +7.7640863123611821e+00*V(F1041) -8.3564854181113510e+00*V(F1049) +3.6928479849898763e+00*V(F1057) +1.0002034477145527e+00*V(F1065) -8.3349773499799962e-01*V(F1066) +1.3431914359853168e+00*V(F1067) -1.6281950360283468e+00*V(F1068) +1.5547099078566993e+00*V(F1069) -1.0664722263749147e+00*V(F1070) +5.1652557487990580e-01*V(F1071) -1.7084205755751738e-01*V(F1072) -4.7435981464870016e+00*V(F1073) +7.5851706292464227e+00*V(F1074) -9.1997216681195209e+00*V(F1075) +8.7839071656971566e+00*V(F1076) -6.0244302378943866e+00*V(F1077) +2.9172616596136001e+00*V(F1078) -9.6554763960912460e-01*V(F1079) +1.0156558784839156e+01*V(F1080) -1.6227456807723705e+01*V(F1081) +1.9682720187370059e+01*V(F1082) -1.8792952895931698e+01*V(F1083) +1.2888895539254804e+01*V(F1084) -6.2411754767658953e+00*V(F1085) +2.0658356462303682e+00*V(F1086) -1.8565318031055913e+01*V(F1087) +2.9660139087449444e+01*V(F1088) -3.5975779308212921e+01*V(F1089) +3.4349452799049800e+01*V(F1090) -2.3558074648241764e+01*V(F1091) +1.1407478719372456e+01*V(F1092) -3.7759127236862460e+00*V(F1093) +2.5394317348264064e+01*V(F1094) -4.0570964506033377e+01*V(F1095) +4.9209821125403550e+01*V(F1096) -4.6985242219037310e+01*V(F1097) +3.2224160494697600e+01*V(F1098) -1.5603846984590044e+01*V(F1099) +5.1649159703425926e+00*V(F1100) -2.5571411588440402e+01*V(F1101) +4.0851083021699878e+01*V(F1102) -4.9549830407567619e+01*V(F1103) +4.7309852068054155e+01*V(F1104) -3.2446741709990505e+01*V(F1105) +1.5711600394478742e+01*V(F1106) -5.2006141185272190e+00*V(F1107) +2.7416374785773421e+01*V(F1108) -4.3855372301825547e+01*V(F1109) +5.3188901235013013e+01*V(F1110) -5.0784998895411142e+01*V(F1111) +3.4831085584301420e+01*V(F1112) -1.6866704679569274e+01*V(F1113) +5.5823226077239942e+00*V(F1114) -1.2130744297399158e+01*V(F1115) +1.9396291838196685e+01*V(F1116) -2.3525015558555712e+01*V(F1117) +2.2461705846420383e+01*V(F1118) -1.5405309135932043e+01*V(F1119) +7.4598342274107248e+00*V(F1120) -2.4690495132590122e+00*V(F1121) -3.2203643453827273e+00*V(F1122) +5.1842269825308804e+00*V(F1123) -6.2847041650823980e+00*V(F1124) +6.0010019363200566e+00*V(F1125) -4.1163689600564979e+00*V(F1126) +1.9936340981500038e+00*V(F1127) -6.5945939705730949e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1108)));
	I(F1109)<+( +2.5716633783608823e-27*V(reduced_0) -1.8834629621513726e-27*V(reduced_1) -1.0731851881110717e-01*V(F841) -5.9740857095657529e-01*V(F850) +1.2761330440494409e+00*V(F859) -2.3321516331469634e+00*V(F868) +3.1901705362302506e+00*V(F877) -3.2117827965437198e+00*V(F886) +3.4563568245092231e+00*V(F895) -1.5274813052150604e+00*V(F904) -4.1341855488152257e-01*V(F913) -3.1126900103521826e-01*V(F1001) -1.7288923608755726e+00*V(F1009) +3.6922341833774963e+00*V(F1017) -6.7474610839957991e+00*V(F1025) +9.2299605507244724e+00*V(F1033) -9.2923028789242164e+00*V(F1041) +1.0003691344642043e+01*V(F1049) -4.4204326212899971e+00*V(F1057) -1.1987357426301226e+00*V(F1065) +1.3431914359845822e+00*V(F1066) -2.6867190594698549e+00*V(F1067) +3.5167218067355202e+00*V(F1068) -3.4391431676434729e+00*V(F1069) +2.5246991424809679e+00*V(F1070) -1.3576490566390365e+00*V(F1071) +5.1652557488846917e-01*V(F1072) +7.5851706292479433e+00*V(F1073) -1.5187332807069184e+01*V(F1074) +1.9829732088207457e+01*V(F1075) -1.9394142819944506e+01*V(F1076) +1.4237008488799576e+01*V(F1077) -7.6567357199516284e+00*V(F1078) +2.9172616596617806e+00*V(F1079) -1.6227456807726323e+01*V(F1080) +3.2494661156187064e+01*V(F1081) -4.2416387033302136e+01*V(F1082) +4.1485066286324887e+01*V(F1083) -3.0453608518819649e+01*V(F1084) +1.6378292674055899e+01*V(F1085) -6.2411754768688006e+00*V(F1086) +2.9660139087454837e+01*V(F1087) -5.9393508862409803e+01*V(F1088) +7.7526468645333622e+01*V(F1089) -7.5824320440502362e+01*V(F1090) +5.5661561835322580e+01*V(F1091) -2.9935445037455139e+01*V(F1092) +1.1407478719560647e+01*V(F1093) -4.0570964506041818e+01*V(F1094) +8.1241906246952666e+01*V(F1095) -1.0604585477504493e+02*V(F1096) +1.0371751972724398e+02*V(F1097) -7.6137569845313294e+01*V(F1098) +4.0947673289712398e+01*V(F1099) -1.5603846984847662e+01*V(F1100) +4.0851083021710899e+01*V(F1101) -8.1803557358890629e+01*V(F1102) +1.0677661740735132e+02*V(F1103) -1.0443232680991694e+02*V(F1104) +7.6662281982491521e+01*V(F1105) -4.1229909416411743e+01*V(F1106) +1.5711600394738536e+01*V(F1107) -4.3855372301825547e+01*V(F1108) +8.7804955699078207e+01*V(F1109) -1.1465797429755128e+02*V(F1110) +1.1213884753940965e+02*V(F1111) -8.2319886302710387e+01*V(F1112) +4.4271832741650755e+01*V(F1113) -1.6866704679846837e+01*V(F1114) +1.9396291838178477e+01*V(F1115) -3.8836334053338931e+01*V(F1116) +5.0706676264948364e+01*V(F1117) -4.9592866426265040e+01*V(F1118) +3.6405523280140692e+01*V(F1119) -1.9579092490916363e+01*V(F1120) +7.4598342275302887e+00*V(F1121) +5.1842269825430201e+00*V(F1122) -1.0371135583175636e+01*V(F1123) +1.3570540338316045e+01*V(F1124) -1.3271345105514824e+01*V(F1125) +9.7425538706759429e+00*V(F1126) -5.2391038509171119e+00*V(F1127) +1.9936340981852732e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1109)));
	I(F1110)<+( -2.9339330647129076e-26*V(reduced_0) +2.1590476671700810e-26*V(reduced_1) +2.4007300961517145e-01*V(F841) +1.3348884109761983e+00*V(F850) -2.8511267090999914e+00*V(F859) +5.2104158117235881e+00*V(F868) -7.1273928868931957e+00*V(F877) +7.1756042116935266e+00*V(F886) -7.7235200097984533e+00*V(F895) +3.4130723983458999e+00*V(F904) +9.2468337545452950e-01*V(F913) +3.9276525498367648e-01*V(F1001) +2.1818848875628483e+00*V(F1009) -4.6597247262471830e+00*V(F1017) +8.5155378013780378e+00*V(F1025) -1.1648536786179827e+01*V(F1033) +1.1727231375280409e+01*V(F1041) -1.2624699053061759e+01*V(F1049) +5.5786508659799914e+00*V(F1057) +1.5126187019065074e+00*V(F1065) -1.6281950360274735e+00*V(F1066) +3.5167218067351516e+00*V(F1067) -5.1602421003386638e+00*V(F1068) +5.4529813110368330e+00*V(F1069) -4.2614636906988785e+00*V(F1070) +2.5246991425109182e+00*V(F1071) -1.0664722264029574e+00*V(F1072) -9.1997216681214375e+00*V(F1073) +1.9829732088207980e+01*V(F1074) -2.9125313081077568e+01*V(F1075) +3.0738279683144626e+01*V(F1076) -2.4025041419020756e+01*V(F1077) +1.4237008488967026e+01*V(F1078) -6.0244302380519050e+00*V(F1079) +1.9682720187373441e+01*V(F1080) -4.2416387033302847e+01*V(F1081) +6.2306281719482058e+01*V(F1082) -6.5747968637489649e+01*V(F1083) +5.1389362372403397e+01*V(F1084) -3.0453608519177447e+01*V(F1085) +1.2888895539591292e+01*V(F1086) -3.5975779308219920e+01*V(F1087) +7.7526468645335044e+01*V(F1088) -1.1388127499460570e+02*V(F1089) +1.2017035752892609e+02*V(F1090) -9.3926650033460646e+01*V(F1091) +5.5661561835976585e+01*V(F1092) -2.3558074648857037e+01*V(F1093) +4.9209821125414507e+01*V(F1094) -1.0604585477504715e+02*V(F1095) +1.5577401379089468e+02*V(F1096) -1.6437711965998020e+02*V(F1097) +1.2847916438401282e+02*V(F1098) -7.6137569846208024e+01*V(F1099) +3.2224160495539699e+01*V(F1100) -4.9549830407581936e+01*V(F1101) +1.0677661740735418e+02*V(F1102) -1.5684881126081228e+02*V(F1103) +1.6550939018410861e+02*V(F1104) -1.2936431981561972e+02*V(F1105) +7.6662281983392589e+01*V(F1106) -3.2446741710839440e+01*V(F1107) +5.3188901235013013e+01*V(F1108) -1.1465797429755128e+02*V(F1109) +1.6839862081744565e+02*V(F1110) -1.7773507420665155e+02*V(F1111) +1.3891686091949043e+02*V(F1112) -8.2319886303678473e+01*V(F1113) +3.4831085585209763e+01*V(F1114) -2.3525015558532061e+01*V(F1115) +5.0706676264943702e+01*V(F1116) -7.4477002499105467e+01*V(F1117) +7.8600772647318024e+01*V(F1118) -6.1434435094765817e+01*V(F1119) +3.6405523280566847e+01*V(F1120) -1.5405309136325533e+01*V(F1121) -6.2847041650981552e+00*V(F1122) +1.3570540338319198e+01*V(F1123) -1.9915248646669585e+01*V(F1124) +2.1041431267856417e+01*V(F1125) -1.6444022901493323e+01*V(F1126) +9.7425538707926655e+00*V(F1127) -4.1163689601703819e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1110)));
	I(F1111)<+( +1.2800006493404721e-26*V(reduced_0) -9.4633816210299639e-27*V(reduced_1) -3.6613961521992172e-01*V(F841) -2.0346705990235430e+00*V(F850) +4.3454869750046896e+00*V(F859) -7.9413029657529792e+00*V(F868) +1.0863022981636215e+01*V(F877) -1.0936444836937479e+01*V(F886) +1.1772707128987786e+01*V(F895) -5.2022669613419668e+00*V(F904) -1.4101417980040665e+00*V(F913) -3.6613961520230992e-01*V(F1001) -2.0346705989283285e+00*V(F1009) +4.3454869748006031e+00*V(F1017) -7.9413029653804337e+00*V(F1025) +1.0863022981127452e+01*V(F1033) -1.0936444836427155e+01*V(F1041) +1.1772707128430699e+01*V(F1049) -5.2022669610815768e+00*V(F1057) -1.4101417979474520e+00*V(F1065) +1.5547099078559015e+00*V(F1066) -3.4391431676431634e+00*V(F1067) +5.4529813110365772e+00*V(F1068) -6.4095175504856696e+00*V(F1069) +5.4529813110907090e+00*V(F1070) -3.4391431677132731e+00*V(F1071) +1.5547099079066582e+00*V(F1072) +8.7839071656989312e+00*V(F1073) -1.9394142819945046e+01*V(F1074) +3.0738279683144917e+01*V(F1075) -3.6163946142880498e+01*V(F1076) +3.0738279683445594e+01*V(F1077) -1.9394142820334650e+01*V(F1078) +8.7839071659775900e+00*V(F1079) -1.8792952895934842e+01*V(F1080) +4.1485066286325704e+01*V(F1081) -6.5747968637489961e+01*V(F1082) +7.7360853099805482e+01*V(F1083) -6.5747968638132761e+01*V(F1084) +4.1485066287158482e+01*V(F1085) -1.8792952896530764e+01*V(F1086) +3.4349452799056316e+01*V(F1087) -7.5824320440504039e+01*V(F1088) +1.2017035752892657e+02*V(F1089) -1.4139702041253412e+02*V(F1090) +1.2017035753010146e+02*V(F1091) -7.5824320442026021e+01*V(F1092) +3.4349452800145116e+01*V(F1093) -4.6985242219047507e+01*V(F1094) +1.0371751972724653e+02*V(F1095) -1.6437711965998099e+02*V(F1096) +1.9341195067787811e+02*V(F1097) -1.6437711966158801e+02*V(F1098) +1.0371751972932834e+02*V(F1099) -4.6985242220536378e+01*V(F1100) +4.7309852068067507e+01*V(F1101) -1.0443232680992028e+02*V(F1102) +1.6550939018410963e+02*V(F1103) -1.9474583981449842e+02*V(F1104) +1.6550939018572748e+02*V(F1105) -1.0443232681201596e+02*V(F1106) +4.7309852069565189e+01*V(F1107) -5.0784998895411142e+01*V(F1108) +1.1213884753940965e+02*V(F1109) -1.7773507420665155e+02*V(F1110) +2.0909838322223325e+02*V(F1111) -1.7773507420839243e+02*V(F1112) +1.1213884754166554e+02*V(F1113) -5.0784998897028821e+01*V(F1114) +2.2461705846398338e+01*V(F1115) -4.9592866426259533e+01*V(F1116) +7.8600772647316376e+01*V(F1117) -9.2475402540022557e+01*V(F1118) +7.8600772648086874e+01*V(F1119) -4.9592866427259196e+01*V(F1120) +2.2461705847122701e+01*V(F1121) +6.0010019363347391e+00*V(F1122) -1.3271345105518527e+01*V(F1123) +2.1041431267857547e+01*V(F1124) -2.4735510387278335e+01*V(F1125) +2.1041431268064571e+01*V(F1126) -1.3271345105786040e+01*V(F1127) +6.0010019365218268e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1111)));
	I(F1112)<+( -2.9845192767941586e-26*V(reduced_0) +2.2166198875640555e-26*V(reduced_1) +3.9276525500336029e-01*V(F841) +2.1818848876693298e+00*V(F850) -4.6597247264754058e+00*V(F859) +8.5155378017946486e+00*V(F868) -1.1648536786748805e+01*V(F877) +1.1727231375851161e+01*V(F886) -1.2624699053684623e+01*V(F895) +5.5786508662707783e+00*V(F904) +1.5126187019700501e+00*V(F913) +2.4007300960445671e-01*V(F1001) +1.3348884109183410e+00*V(F1009) -2.8511267089759627e+00*V(F1017) +5.2104158114971977e+00*V(F1025) -7.1273928865840386e+00*V(F1033) +7.1756042113834750e+00*V(F1041) -7.7235200094597909e+00*V(F1049) +3.4130723981872748e+00*V(F1057) +9.2468337542034318e-01*V(F1065) -1.0664722263744062e+00*V(F1066) +2.5246991424807530e+00*V(F1067) -4.2614636906987009e+00*V(F1068) +5.4529813110904746e+00*V(F1069) -5.1602421004316890e+00*V(F1070) +3.5167218068260930e+00*V(F1071) -1.6281950360865585e+00*V(F1072) -6.0244302378955146e+00*V(F1073) +1.4237008488799948e+01*V(F1074) -2.4025041419020965e+01*V(F1075) +3.0738279683445793e+01*V(F1076) -2.9125313081597007e+01*V(F1077) +1.9829732088713456e+01*V(F1078) -9.1997216684461023e+00*V(F1079) +1.2888895539256813e+01*V(F1080) -3.0453608518820204e+01*V(F1081) +5.1389362372403625e+01*V(F1082) -6.5747968638132861e+01*V(F1083) +6.2306281720591919e+01*V(F1084) -4.2416387034383320e+01*V(F1085) +1.9682720188067698e+01*V(F1086) -2.3558074648245917e+01*V(F1087) +5.5661561835323738e+01*V(F1088) -9.3926650033461101e+01*V(F1089) +1.2017035753010158e+02*V(F1090) -1.1388127499663408e+02*V(F1091) +7.7526468647309727e+01*V(F1092) -3.5975779309488452e+01*V(F1093) +3.2224160494704094e+01*V(F1094) -7.6137569845315113e+01*V(F1095) +1.2847916438401353e+02*V(F1096) -1.6437711966158813e+02*V(F1097) +1.5577401379366933e+02*V(F1098) -1.0604585477774819e+02*V(F1099) +4.9209821127149205e+01*V(F1100) -3.2446741709999003e+01*V(F1101) +7.6662281982493866e+01*V(F1102) -1.2936431981562066e+02*V(F1103) +1.6550939018572768e+02*V(F1104) -1.5684881126360597e+02*V(F1105) +1.0677661741007338e+02*V(F1106) -4.9549830409327022e+01*V(F1107) +3.4831085584301420e+01*V(F1108) -8.2319886302710387e+01*V(F1109) +1.3891686091949043e+02*V(F1110) -1.7773507420839243e+02*V(F1111) +1.6839862082045056e+02*V(F1112) -1.1465797430047763e+02*V(F1113) +5.3188901236897287e+01*V(F1114) -1.5405309135918005e+01*V(F1115) +3.6405523280136840e+01*V(F1116) -6.1434435094764318e+01*V(F1117) +7.8600772648086632e+01*V(F1118) -7.4477002500433741e+01*V(F1119) +5.0706676266239164e+01*V(F1120) -2.3525015559374847e+01*V(F1121) -4.1163689600658468e+00*V(F1122) +9.7425538706785222e+00*V(F1123) -1.6444022901494339e+01*V(F1124) +2.1041431268064784e+01*V(F1125) -1.9915248647028104e+01*V(F1126) +1.3570540338667083e+01*V(F1127) -6.2847041653166977e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1112)));
	I(F1113)<+( +2.6611146068667548e-27*V(reduced_0) -1.9852674980875219e-27*V(reduced_1) -3.1126900105110777e-01*V(F841) -1.7288923609615556e+00*V(F850) +3.6922341835617778e+00*V(F859) -6.7474610843322100e+00*V(F868) +9.2299605511839324e+00*V(F877) -9.2923028793851490e+00*V(F886) +1.0003691345144906e+01*V(F895) -4.4204326215245100e+00*V(F904) -1.1987357426815965e+00*V(F913) -1.0731851880701110e-01*V(F1001) -5.9740857093452360e-01*V(F1009) +1.2761330440021554e+00*V(F1017) -2.3321516330606595e+00*V(F1025) +3.1901705361124151e+00*V(F1033) -3.2117827964255818e+00*V(F1041) +3.4563568243800113e+00*V(F1049) -1.5274813051542457e+00*V(F1057) -4.1341855486868473e-01*V(F1065) +5.1652557487968775e-01*V(F1066) -1.3576490566389126e+00*V(F1067) +2.5246991425107623e+00*V(F1068) -3.4391431677130631e+00*V(F1069) +3.5167218068258128e+00*V(F1070) -2.6867190595490658e+00*V(F1071) +1.3431914360337358e+00*V(F1072) +2.9172616596140730e+00*V(F1073) -7.6567357199518007e+00*V(F1074) +1.4237008488967163e+01*V(F1075) -1.9394142820334796e+01*V(F1076) +1.9829732088713637e+01*V(F1077) -1.5187332807511167e+01*V(F1078) +7.5851706295179131e+00*V(F1079) -6.2411754767667231e+00*V(F1080) +1.6378292674056130e+01*V(F1081) -3.0453608519177525e+01*V(F1082) +4.1485066287158467e+01*V(F1083) -4.2416387034383291e+01*V(F1084) +3.2494661157131432e+01*V(F1085) -1.6227456808303671e+01*V(F1086) +1.1407478719374168e+01*V(F1087) -2.9935445037455580e+01*V(F1088) +5.5661561835976684e+01*V(F1089) -7.5824320442025879e+01*V(F1090) +7.7526468647309514e+01*V(F1091) -5.9393508864135683e+01*V(F1092) +2.9660139088509784e+01*V(F1093) -1.5603846984592717e+01*V(F1094) +4.0947673289713109e+01*V(F1095) -7.6137569846208194e+01*V(F1096) +1.0371751972932815e+02*V(F1097) -1.0604585477774788e+02*V(F1098) +8.1241906249313544e+01*V(F1099) -4.0570964507484476e+01*V(F1100) +1.5711600394482240e+01*V(F1101) -4.1229909416412667e+01*V(F1102) +7.6662281983392774e+01*V(F1103) -1.0443232681201566e+02*V(F1104) +1.0677661741007297e+02*V(F1105) -8.1803557361267593e+01*V(F1106) +4.0851083023162303e+01*V(F1107) -1.6866704679569274e+01*V(F1108) +4.4271832741650755e+01*V(F1109) -8.2319886303678473e+01*V(F1110) +1.1213884754166554e+02*V(F1111) -1.1465797430047763e+02*V(F1112) +8.7804955701635222e+01*V(F1113) -4.3855372303392286e+01*V(F1114) +7.4598342274049410e+00*V(F1115) -1.9579092490914874e+01*V(F1116) +3.6405523280566570e+01*V(F1117) -4.9592866427259729e+01*V(F1118) +5.0706676266239946e+01*V(F1119) -3.8836334054469177e+01*V(F1120) +1.9396291838878490e+01*V(F1121) +1.9936340981538556e+00*V(F1122) -5.2391038509181183e+00*V(F1123) +9.7425538707928716e+00*V(F1124) -1.3271345105785731e+01*V(F1125) +1.3570540338666612e+01*V(F1126) -1.0371135583480898e+01*V(F1127) +5.1842269827252361e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1113)));
	I(F1114)<+( -1.7026201522923836e-26*V(reduced_0) +1.2757663044616029e-26*V(reduced_1) +2.5966917120304611e-01*V(F841) +1.4443079512841213e+00*V(F850) -3.0849355751260759e+00*V(F859) +5.6377179627646905e+00*V(F868) -7.7118989017353945e+00*V(F877) +7.7640863127139470e+00*V(F886) -8.3564854184958168e+00*V(F895) +3.6928479851685201e+00*V(F904) +1.0002034477543575e+00*V(F913) +3.1007351448006662e-02*V(F1001) +1.7307966461080906e-01*V(F1009) -3.6982558639444946e-01*V(F1017) +6.7588006178927051e-01*V(F1025) -9.2453612384255102e-01*V(F1033) +9.3082249718875598e-01*V(F1041) -1.0012390693908904e+00*V(F1049) +4.4254745869371237e-01*V(F1057) +1.1949153117141832e-01*V(F1065) -1.7084205755744505e-01*V(F1066) +5.1652557488835982e-01*V(F1067) -1.0664722264027280e+00*V(F1068) +1.5547099079063011e+00*V(F1069) -1.6281950360861608e+00*V(F1070) +1.3431914360333677e+00*V(F1071) -8.3349773502991065e-01*V(F1072) -9.6554763960924472e-01*V(F1073) +2.9172616596618433e+00*V(F1074) -6.0244302380519885e+00*V(F1075) +8.7839071659777002e+00*V(F1076) -9.1997216684462266e+00*V(F1077) +7.5851706295180454e+00*V(F1078) -4.7435981466641781e+00*V(F1079) +2.0658356462305494e+00*V(F1080) -6.2411754768687713e+00*V(F1081) +1.2888895539591104e+01*V(F1082) -1.8792952896530412e+01*V(F1083) +1.9682720188067311e+01*V(F1084) -1.6227456808303348e+01*V(F1085) +1.0156558785217513e+01*V(F1086) -3.7759127236866101e+00*V(F1087) +1.1407478719560540e+01*V(F1088) -2.3558074648856515e+01*V(F1089) +3.4349452800144235e+01*V(F1090) -3.5975779309487436e+01*V(F1091) +2.9660139088508949e+01*V(F1092) -1.8565318031747346e+01*V(F1093) +5.1649159703431602e+00*V(F1094) -1.5603846984847477e+01*V(F1095) +3.2224160495538861e+01*V(F1096) -4.6985242220534921e+01*V(F1097) +4.9209821127147571e+01*V(F1098) -4.0570964507483119e+01*V(F1099) +2.5394317349209910e+01*V(F1100) -5.2006141185279571e+00*V(F1101) +1.5711600394738291e+01*V(F1102) -3.2446741710838332e+01*V(F1103) +4.7309852069563263e+01*V(F1104) -4.9549830409324869e+01*V(F1105) +4.0851083023160498e+01*V(F1106) -2.5571411589392625e+01*V(F1107) +5.5823226077239942e+00*V(F1108) -1.6866704679846837e+01*V(F1109) +3.4831085585209763e+01*V(F1110) -5.0784998897028821e+01*V(F1111) +5.3188901236897287e+01*V(F1112) -4.3855372303392286e+01*V(F1113) +2.7416374786798677e+01*V(F1114) -2.4690495132577990e+00*V(F1115) +7.4598342275307283e+00*V(F1116) -1.5405309136327439e+01*V(F1117) +2.2461705847125984e+01*V(F1118) -2.3525015559378545e+01*V(F1119) +1.9396291838881595e+01*V(F1120) -1.2130744297852203e+01*V(F1121) -6.5945939705812129e-01*V(F1122) +1.9936340981849969e+00*V(F1123) -4.1163689601691518e+00*V(F1124) +6.0010019365196996e+00*V(F1125) -6.2847041653143085e+00*V(F1126) +5.1842269827232412e+00*V(F1127) -3.2203643455056512e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1114)));
	I(F1115)<+( +1.0262339403854877e-25*V(reduced_0) -7.4744246215399903e-26*V(reduced_1) -5.3344260214309601e-03*V(F841) -6.2293090287571663e-02*V(F850) +1.7307966461490784e-01*V(F859) -3.6619554294680851e-01*V(F868) +5.4502753185478092e-01*V(F877) -5.7565653919355408e-01*V(F886) +4.4254745870517476e-01*V(F895) -5.5700564245368567e-01*V(F904) -8.4166396705921437e-02*V(F913) -4.4730592030345503e-02*V(F1001) -5.1989012973148130e-01*V(F1009) +1.4443079512202666e+00*V(F1017) -3.0559347097869969e+00*V(F1025) +4.5484537331261325e+00*V(F1033) -4.8041279220815802e+00*V(F1041) +3.6928479850077820e+00*V(F1049) -4.6518939306643530e+00*V(F1057) -7.0470066543342713e-01*V(F1065) +1.4236836453337579e-01*V(F1066) -2.3009393378775847e-01*V(F1067) +2.7885881365951937e-01*V(F1068) -2.6627991136664492e-01*V(F1069) +1.8266917629299045e-01*V(F1070) -8.8478608014285712e-02*V(F1071) +2.9257127597836760e-02*V(F1072) +1.7060381360558028e+00*V(F1073) -2.7287953076615445e+00*V(F1074) +3.3095684105486081e+00*V(F1075) -3.1599886286362397e+00*V(F1076) +2.1672870188555571e+00*V(F1077) -1.0494914572802614e+00*V(F1078) +3.4734918095446754e-01*V(F1079) -4.7435981464877930e+00*V(F1080) +7.5851706292459680e+00*V(F1081) -9.1997216681187979e+00*V(F1082) +8.7839071656965100e+00*V(F1083) -6.0244302378940429e+00*V(F1084) +2.9172616596135330e+00*V(F1085) -9.6554763960917733e-01*V(F1086) +1.0034175411129343e+01*V(F1087) -1.6046351536020197e+01*V(F1088) +1.9461798707223796e+01*V(F1089) -1.8582166851475375e+01*V(F1090) +1.2744576020087688e+01*V(F1091) -6.1714286458857064e+00*V(F1092) +2.0425879859798282e+00*V(F1093) -1.4931715508060595e+01*V(F1094) +2.3880046023422533e+01*V(F1095) -2.8962738691215311e+01*V(F1096) +2.7653702024373757e+01*V(F1097) -1.8966315694096789e+01*V(F1098) +9.1842575663530699e+00*V(F1099) -3.0397397932154218e+00*V(F1100) +1.5769701776388604e+01*V(F1101) -2.5220946527448895e+01*V(F1102) +3.0588977274588594e+01*V(F1103) -2.9206446502340132e+01*V(F1104) +2.0031279126749798e+01*V(F1105) -9.6999628052819062e+00*V(F1106) +3.2104161428194975e+00*V(F1107) -1.2130744297399158e+01*V(F1108) +1.9396291838178477e+01*V(F1109) -2.3525015558532061e+01*V(F1110) +2.2461705846398338e+01*V(F1111) -1.5405309135918005e+01*V(F1112) +7.4598342274049410e+00*V(F1113) -2.4690495132577990e+00*V(F1114) +1.5198181644706217e+01*V(F1115) -2.4345528273791924e+01*V(F1116) +2.9523881203288326e+01*V(F1117) -2.8189886955795252e+01*V(F1118) +1.9334726426262005e+01*V(F1119) -9.3630295560113730e+00*V(F1120) +3.0984690626755764e+00*V(F1121) +2.2650310113495848e+00*V(F1122) -3.6484455267899909e+00*V(F1123) +4.4227315642126337e+00*V(F1124) -4.2231038139675663e+00*V(F1125) +2.8968612733592258e+00*V(F1126) -1.4030239693582895e+00*V(F1127) +4.6407211752089272e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1115)));
	I(F1116)<+( -1.6316227435340841e-26*V(reduced_0) +1.1941826211940686e-26*V(reduced_1) +1.8481154365708789e-02*V(F841) +2.1503530714113628e-01*V(F850) -5.9740857095669897e-01*V(F859) +1.2640135007616586e+00*V(F868) -1.8813435066301789e+00*V(F877) +1.9870900058332945e+00*V(F886) -1.5274813052151672e+00*V(F895) +1.9237948239281590e+00*V(F904) +2.9125925823164478e-01*V(F913) +5.3646381170128404e-02*V(F1001) +6.2236132981814196e-01*V(F1009) -1.7288923608782072e+00*V(F1017) +3.6581291933842852e+00*V(F1025) -5.4448309999507059e+00*V(F1033) +5.7509218783356140e+00*V(F1041) -4.4204326213148537e+00*V(F1049) +5.5703004214491649e+00*V(F1057) +8.4466575176151582e-01*V(F1065) -2.3009393378746912e-01*V(F1066) +4.6007573629269638e-01*V(F1067) -6.0276143913476365e-01*V(F1068) +5.8944372383915822e-01*V(F1069) -4.3271891270528640e-01*V(F1070) +2.3268391800254093e-01*V(F1071) -8.8478608015737190e-02*V(F1072) -2.7287953076629337e+00*V(F1073) +5.4635019834901728e+00*V(F1074) -7.1342204965401512e+00*V(F1075) +6.9774820693036324e+00*V(F1076) -5.1220911242079934e+00*V(F1077) +2.7546756315443295e+00*V(F1078) -1.0494914572977536e+00*V(F1079) +7.5851706292508068e+00*V(F1080) -1.5187332807071598e+01*V(F1081) +1.9829732088210193e+01*V(F1082) -1.9394142819947078e+01*V(F1083) +1.4237008488801475e+01*V(F1084) -7.6567357199527271e+00*V(F1085) +2.9172616596623326e+00*V(F1086) -1.6046351536031711e+01*V(F1087) +3.2128295822854227e+01*V(F1088) -4.1950289688229375e+01*V(F1089) +4.1028746423882424e+01*V(F1090) -3.0118721075454065e+01*V(F1091) +1.6197982285741613e+01*V(F1092) -6.1714286459891863e+00*V(F1093) +2.3880046023440794e+01*V(F1094) -4.7812625189434783e+01*V(F1095) +6.2430925467456234e+01*V(F1096) -6.1059420125347451e+01*V(F1097) +4.4823014116113541e+01*V(F1098) -2.4105992583589217e+01*V(F1099) +9.1842575665072825e+00*V(F1100) -2.5220946527469241e+01*V(F1101) +5.0497190279128731e+01*V(F1102) -6.5936880553343713e+01*V(F1103) +6.4488332271906174e+01*V(F1104) -4.7340143398554808e+01*V(F1105) +2.5459704356665743e+01*V(F1106) -9.6999628054449740e+00*V(F1107) +1.9396291838196685e+01*V(F1108) -3.8836334053338931e+01*V(F1109) +5.0706676264943702e+01*V(F1110) -4.9592866426259533e+01*V(F1111) +3.6405523280136840e+01*V(F1112) -1.9579092490914874e+01*V(F1113) +7.4598342275307283e+00*V(F1114) -2.4345528273791924e+01*V(F1115) +4.8734509444442814e+01*V(F1116) -6.3667702592649448e+01*V(F1117) +6.2267784782347974e+01*V(F1118) -4.5710307271064799e+01*V(F1119) +2.4582626561892589e+01*V(F1120) -9.3630295561658663e+00*V(F1121) -3.6484455267992111e+00*V(F1122) +7.2982322476838153e+00*V(F1123) -9.5514598044512518e+00*V(F1124) +9.3408078200253488e+00*V(F1125) -6.8571421606441216e+00*V(F1126) +3.6874302301455648e+00*V(F1127) -1.4030239693832525e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1116)));
	I(F1117)<+( +1.8614696252937184e-25*V(reduced_0) -1.3689260137504571e-25*V(reduced_1) -4.1359721804237956e-02*V(F841) -4.8050943508808291e-01*V(F850) +1.3348884109764889e+00*V(F859) -2.8244297484506449e+00*V(F868) +4.2038941220926995e+00*V(F877) -4.4402054812450205e+00*V(F886) +3.4130723983462556e+00*V(F895) -4.2997862141844720e+00*V(F904) -6.5150779994590580e-01*V(F913) -6.7688275657795463e-02*V(F1001) -7.8542363452233832e-01*V(F1009) +2.1818848875661736e+00*V(F1017) -4.6165991725336859e+00*V(F1025) +6.8714266222535443e+00*V(F1033) -7.2577119258748750e+00*V(F1041) +5.5786508660113467e+00*V(F1049) -7.0295422306778033e+00*V(F1057) -1.0658251080346182e+00*V(F1065) +2.7885881365916282e-01*V(F1066) -6.0276143913464608e-01*V(F1067) +8.8414077442044170e-01*V(F1068) -9.3473983805972183e-01*V(F1069) +7.3045492061523387e-01*V(F1070) -4.3271891271042484e-01*V(F1071) +1.8266917629775961e-01*V(F1072) +3.3095684105503986e+00*V(F1073) -7.1342204965405420e+00*V(F1074) +1.0478150367672434e+01*V(F1075) -1.1058957546533799e+01*V(F1076) +8.6436377200573720e+00*V(F1077) -5.1220911242683496e+00*V(F1078) +2.1672870189126425e+00*V(F1079) -9.1997216681250791e+00*V(F1080) +1.9829732088211451e+01*V(F1081) -2.9125313081082169e+01*V(F1082) +3.0738279683149358e+01*V(F1083) -2.4025041419024447e+01*V(F1084) +1.4237008488969305e+01*V(F1085) -6.0244302380531565e+00*V(F1086) +1.9461798707238753e+01*V(F1087) -4.1950289688232331e+01*V(F1088) +6.1614660134061360e+01*V(F1089) -6.5027813287328968e+01*V(F1090) +5.0825665691958804e+01*V(F1091) -3.0118721075809283e+01*V(F1092) +1.2744576020424931e+01*V(F1093) -2.8962738691239053e+01*V(F1094) +6.2430925467460916e+01*V(F1095) -9.1694860808757269e+01*V(F1096) +9.6775446301112538e+01*V(F1097) -7.5639484265654929e+01*V(F1098) +4.4823014116642348e+01*V(F1099) -1.8966315694599235e+01*V(F1100) +3.0588977274615029e+01*V(F1101) -6.5936880553348928e+01*V(F1102) +9.6843852485433473e+01*V(F1103) -1.0221021480359147e+02*V(F1104) +7.9887247058117794e+01*V(F1105) -4.7340143399113444e+01*V(F1106) +2.0031279127280957e+01*V(F1107) -2.3525015558555712e+01*V(F1108) +5.0706676264948364e+01*V(F1109) -7.4477002499105467e+01*V(F1110) +7.8600772647316376e+01*V(F1111) -6.1434435094764318e+01*V(F1112) +3.6405523280566570e+01*V(F1113) -1.5405309136327439e+01*V(F1114) +2.9523881203288326e+01*V(F1115) -6.3667702592649448e+01*V(F1116) +9.3492415025764714e+01*V(F1117) -9.8698925245468615e+01*V(F1118) +7.7140652772972274e+01*V(F1119) -4.5710307271603412e+01*V(F1120) +1.9334726426767517e+01*V(F1121) +4.4227315642246028e+00*V(F1122) -9.5514598044536392e+00*V(F1123) +1.4016082803341902e+01*V(F1124) -1.4810096935760555e+01*V(F1125) +1.1574072661902859e+01*V(F1126) -6.8571421607264078e+00*V(F1127) +2.8968612734397516e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1117)));
	I(F1118)<+( -8.1211225221124526e-26*V(reduced_0) +6.0002324522706921e-26*V(reduced_1) +6.3091844915807202e-02*V(F841) +7.3242075299761833e-01*V(F850) -2.0346705990239942e+00*V(F859) +4.3050953675435588e+00*V(F868) -6.4077585083999926e+00*V(F877) +6.7679694597950020e+00*V(F886) -5.2022669613425689e+00*V(F895) +6.5547312367276254e+00*V(F904) +9.9359234050101475e-01*V(F913) +6.3091844912665396e-02*V(F1001) +7.3242075296401676e-01*V(F1009) -2.0346705989313736e+00*V(F1017) +4.3050953673486063e+00*V(F1025) -6.4077585081107422e+00*V(F1033) +6.7679694594903204e+00*V(F1041) -5.2022669611102241e+00*V(F1049) +6.5547312364182835e+00*V(F1057) +9.9359234046169242e-01*V(F1065) -2.6627991136631640e-01*V(F1066) +5.8944372383904886e-01*V(F1067) -9.3473983805965011e-01*V(F1068) +1.0983285024317493e+00*V(F1069) -9.3473983806898375e-01*V(F1070) +5.8944372385114319e-01*V(F1071) -2.6627991137515172e-01*V(F1072) -3.1599886286379060e+00*V(F1073) +6.9774820693040720e+00*V(F1074) -1.1058957546533962e+01*V(F1075) +1.3010542554518688e+01*V(F1076) -1.1058957546642159e+01*V(F1077) +6.9774820694442026e+00*V(F1078) -3.1599886287377958e+00*V(F1079) +8.7839071657023666e+00*V(F1080) -1.9394142819948549e+01*V(F1081) +3.0738279683149813e+01*V(F1082) -3.6163946142886211e+01*V(F1083) +3.0738279683450497e+01*V(F1084) -1.9394142820337859e+01*V(F1085) +8.7839071659794836e+00*V(F1086) -1.8582166851489315e+01*V(F1087) +4.1028746423885927e+01*V(F1088) -6.5027813287330019e+01*V(F1089) +7.6505195138662756e+01*V(F1090) -6.5027813287966168e+01*V(F1091) +4.1028746424709446e+01*V(F1092) -1.8582166852075012e+01*V(F1093) +2.7653702024395880e+01*V(F1094) -6.1059420125352979e+01*V(F1095) +9.6775446301114158e+01*V(F1096) -1.1385529747782952e+02*V(F1097) +9.6775446302060942e+01*V(F1098) -6.1059420126578530e+01*V(F1099) +2.7653702025267048e+01*V(F1100) -2.9206446502364773e+01*V(F1101) +6.4488332271912341e+01*V(F1102) -1.0221021480359330e+02*V(F1103) +1.2024883014299910e+02*V(F1104) -1.0221021480459324e+02*V(F1105) +6.4488332273206638e+01*V(F1106) -2.9206446503284376e+01*V(F1107) +2.2461705846420383e+01*V(F1108) -4.9592866426265040e+01*V(F1109) +7.8600772647318024e+01*V(F1110) -9.2475402540022557e+01*V(F1111) +7.8600772648086632e+01*V(F1112) -4.9592866427259729e+01*V(F1113) +2.2461705847125984e+01*V(F1114) -2.8189886955795252e+01*V(F1115) +6.2267784782347974e+01*V(F1116) -9.8698925245468615e+01*V(F1117) +1.1609564782367227e+02*V(F1118) -9.8698925246437057e+01*V(F1119) +6.2267784783603041e+01*V(F1120) -2.8189886956695499e+01*V(F1121) -4.2231038139787200e+00*V(F1122) +9.3408078200281590e+00*V(F1123) -1.4810096935761411e+01*V(F1124) +1.7408969996891127e+01*V(F1125) -1.4810096935907207e+01*V(F1126) +9.3408078202165026e+00*V(F1127) -4.2231038141101802e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1118)));
	I(F1119)<+( +1.8935657046828026e-25*V(reduced_0) -1.4054545949655000e-25*V(reduced_1) -6.7688275661304323e-02*V(F841) -7.8542363455993258e-01*V(F850) +2.1818848876698196e+00*V(F859) -4.6165991727518687e+00*V(F868) +6.8714266225772933e+00*V(F877) -7.2577119262159151e+00*V(F886) +5.5786508662714622e+00*V(F895) -7.0295422310236839e+00*V(F904) -1.0658251080787684e+00*V(F913) -4.1359721802323959e-02*V(F1001) -4.8050943506768073e-01*V(F1009) +1.3348884109202692e+00*V(F1017) -2.8244297483323368e+00*V(F1025) +4.2038941219171857e+00*V(F1033) -4.4402054810601648e+00*V(F1041) +3.4130723982053341e+00*V(F1049) -4.2997862139964340e+00*V(F1057) -6.5150779992217600e-01*V(F1065) +1.8266917629278140e-01*V(F1066) -4.3271891270521079e-01*V(F1067) +7.3045492061518202e-01*V(F1068) -9.3473983806892469e-01*V(F1069) +8.8414077443644157e-01*V(F1070) -6.0276143915032365e-01*V(F1071) +2.7885881366943904e-01*V(F1072) +2.1672870188566185e+00*V(F1073) -5.1220911242082963e+00*V(F1074) +8.6436377200575087e+00*V(F1075) -1.1058957546642217e+01*V(F1076) +1.0478150367859381e+01*V(F1077) -7.1342204967224117e+00*V(F1078) +3.3095684106668215e+00*V(F1079) -6.0244302378977688e+00*V(F1080) +1.4237008488802505e+01*V(F1081) -2.4025041419024856e+01*V(F1082) +3.0738279683450575e+01*V(F1083) -2.9125313081601632e+01*V(F1084) +1.9829732088716778e+01*V(F1085) -9.1997216684481202e+00*V(F1086) +1.2744576020096567e+01*V(F1087) -3.0118721075456502e+01*V(F1088) +5.0825665691959749e+01*V(F1089) -6.5027813287966339e+01*V(F1090) +6.1614660135160406e+01*V(F1091) -4.1950289689301400e+01*V(F1092) +1.9461798707921574e+01*V(F1093) -1.8966315694110875e+01*V(F1094) +4.4823014116117399e+01*V(F1095) -7.5639484265656435e+01*V(F1096) +9.6775446302061226e+01*V(F1097) -9.1694860810393081e+01*V(F1098) +6.2430925469052006e+01*V(F1099) -2.8962738692254746e+01*V(F1100) +2.0031279126765494e+01*V(F1101) -4.7340143398559114e+01*V(F1102) +7.9887247058119414e+01*V(F1103) -1.0221021480459351e+02*V(F1104) +9.6843852487161243e+01*V(F1105) -6.5936880555029333e+01*V(F1106) +3.0588977275687252e+01*V(F1107) -1.5405309135932043e+01*V(F1108) +3.6405523280140692e+01*V(F1109) -6.1434435094765817e+01*V(F1110) +7.8600772648086874e+01*V(F1111) -7.4477002500433741e+01*V(F1112) +5.0706676266239946e+01*V(F1113) -2.3525015559378545e+01*V(F1114) +1.9334726426262005e+01*V(F1115) -4.5710307271064799e+01*V(F1116) +7.7140652772972274e+01*V(F1117) -9.8698925246437057e+01*V(F1118) +9.3492415027436380e+01*V(F1119) -6.3667702594277507e+01*V(F1120) +2.9523881204336945e+01*V(F1121) +2.8968612733663281e+00*V(F1122) -6.8571421606460774e+00*V(F1123) +1.1574072661903624e+01*V(F1124) -1.4810096935907362e+01*V(F1125) +1.4016082803594434e+01*V(F1126) -9.5514598046986237e+00*V(F1127) +4.4227315643781999e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1119)));
	I(F1120)<+( -1.6883780057578161e-26*V(reduced_0) +1.2587758439942186e-26*V(reduced_1) +5.3646381172959182e-02*V(F841) +6.2236132984851145e-01*V(F850) -1.7288923609619502e+00*V(F859) +3.6581291935605926e+00*V(F868) -5.4448310002123277e+00*V(F877) +5.7509218786112299e+00*V(F886) -4.4204326215251024e+00*V(F895) +5.5703004217284180e+00*V(F904) +8.4466575179729231e-01*V(F913) +1.8481154364974790e-02*V(F1001) +2.1503530713337435e-01*V(F1009) -5.9740857093532607e-01*V(F1017) +1.2640135007167037e+00*V(F1025) -1.8813435065635076e+00*V(F1033) +1.9870900057630918e+00*V(F1041) -1.5274813051616922e+00*V(F1049) +1.9237948238564284e+00*V(F1057) +2.9125925822274734e-01*V(F1065) -8.8478608014197421e-02*V(F1066) +2.3268391800250154e-01*V(F1067) -4.3271891271038543e-01*V(F1068) +5.8944372385109545e-01*V(F1069) -6.0276143915026059e-01*V(F1070) +4.6007573630632476e-01*V(F1071) -2.3009393379601564e-01*V(F1072) -1.0494914572806997e+00*V(F1073) +2.7546756315444560e+00*V(F1074) -5.1220911242683975e+00*V(F1075) +6.9774820694442061e+00*V(F1076) -7.1342204967224108e+00*V(F1077) +5.4635019836492553e+00*V(F1078) -2.7287953077597829e+00*V(F1079) +2.9172616596150687e+00*V(F1080) -7.6567357199531267e+00*V(F1081) +1.4237008488969385e+01*V(F1082) -1.9394142820337727e+01*V(F1083) +1.9829732088716586e+01*V(F1084) -1.5187332807513611e+01*V(F1085) +7.5851706295195953e+00*V(F1086) -6.1714286458893621e+00*V(F1087) +1.6197982285742551e+01*V(F1088) -3.0118721075809457e+01*V(F1089) +4.1028746424709105e+01*V(F1090) -4.1950289689300895e+01*V(F1091) +3.2128295823789450e+01*V(F1092) -1.6046351536599929e+01*V(F1093) +9.1842575663588715e+00*V(F1094) -2.4105992583590712e+01*V(F1095) +4.4823014116642625e+01*V(F1096) -6.1059420126578019e+01*V(F1097) +6.2430925469051211e+01*V(F1098) -4.7812625190826751e+01*V(F1099) +2.3880046024286059e+01*V(F1100) -9.6999628052883722e+00*V(F1101) +2.5459704356667405e+01*V(F1102) -4.7340143399113749e+01*V(F1103) +6.4488332273206055e+01*V(F1104) -6.5936880555028424e+01*V(F1105) +5.0497190280598915e+01*V(F1106) -2.5220946528361580e+01*V(F1107) +7.4598342274107248e+00*V(F1108) -1.9579092490916363e+01*V(F1109) +3.6405523280566847e+01*V(F1110) -4.9592866427259196e+01*V(F1111) +5.0706676266239164e+01*V(F1112) -3.8836334054469177e+01*V(F1113) +1.9396291838881595e+01*V(F1114) -9.3630295560113730e+00*V(F1115) +2.4582626561892589e+01*V(F1116) -4.5710307271603412e+01*V(F1117) +6.2267784783603041e+01*V(F1118) -6.3667702594277507e+01*V(F1119) +4.8734509445865513e+01*V(F1120) -2.4345528274663845e+01*V(F1121) -1.4030239693612152e+00*V(F1122) +3.6874302301463260e+00*V(F1123) -6.8571421607265606e+00*V(F1124) +9.3408078202162628e+00*V(F1125) -9.5514598046982577e+00*V(F1126) +7.2982322478988459e+00*V(F1127) -3.6484455269273059e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1120)));
	I(F1121)<+( +1.0802492935014896e-25*V(reduced_0) -8.0891739151424224e-26*V(reduced_1) -4.4730592032504693e-02*V(F841) -5.1989012975474669e-01*V(F850) +1.4443079512844643e+00*V(F859) -3.0559347099222052e+00*V(F868) +4.5484537333268156e+00*V(F877) -4.8041279222930342e+00*V(F886) +3.6928479851691809e+00*V(F895) -4.6518939308778835e+00*V(F904) -7.0470066546112431e-01*V(F913) -5.3344260212907692e-03*V(F1001) -6.2293090286149343e-02*V(F1009) +1.7307966461100563e-01*V(F1017) -3.6619554293862094e-01*V(F1025) +5.4502753184265684e-01*V(F1033) -5.7565653918080428e-01*V(F1041) +4.4254745869550183e-01*V(F1049) -5.5700564244035977e-01*V(F1057) -8.4166396704412241e-02*V(F1065) +2.9257127597811784e-02*V(F1066) -8.8478608015713417e-02*V(F1067) +1.8266917629771534e-01*V(F1068) -2.6627991137508533e-01*V(F1069) +2.7885881366936510e-01*V(F1070) -2.3009393379594537e-01*V(F1071) +1.4236836453887611e-01*V(F1072) +3.4734918095456452e-01*V(F1073) -1.0494914572977443e+00*V(F1074) +2.1672870189125537e+00*V(F1075) -3.1599886287376364e+00*V(F1076) +3.3095684106666425e+00*V(F1077) -2.7287953077596390e+00*V(F1078) +1.7060381361195855e+00*V(F1079) -9.6554763960950096e-01*V(F1080) +2.9172616596622216e+00*V(F1081) -6.0244302380526618e+00*V(F1082) +8.7839071659786310e+00*V(F1083) -9.1997216684471610e+00*V(F1084) +7.5851706295187933e+00*V(F1085) -4.7435981466649766e+00*V(F1086) +2.0425879859805955e+00*V(F1087) -6.1714286459889038e+00*V(F1088) +1.2744576020423722e+01*V(F1089) -1.8582166852072927e+01*V(F1090) +1.9461798707919225e+01*V(F1091) -1.6046351536597967e+01*V(F1092) +1.0034175411504252e+01*V(F1093) -3.0397397932166377e+00*V(F1094) +9.1842575665068349e+00*V(F1095) -1.8966315694597309e+01*V(F1096) +2.7653702025263730e+01*V(F1097) -2.8962738692251001e+01*V(F1098) +2.3880046024282926e+01*V(F1099) -1.4931715508618627e+01*V(F1100) +3.2104161428208520e+00*V(F1101) -9.6999628054444695e+00*V(F1102) +2.0031279127278804e+01*V(F1103) -2.9206446503280667e+01*V(F1104) +3.0588977275683092e+01*V(F1105) -2.5220946528358091e+01*V(F1106) +1.5769701776978017e+01*V(F1107) -2.4690495132590122e+00*V(F1108) +7.4598342275302887e+00*V(F1109) -1.5405309136325533e+01*V(F1110) +2.2461705847122701e+01*V(F1111) -2.3525015559374847e+01*V(F1112) +1.9396291838878490e+01*V(F1113) -1.2130744297852203e+01*V(F1114) +3.0984690626755764e+00*V(F1115) -9.3630295561658663e+00*V(F1116) +1.9334726426767517e+01*V(F1117) -2.8189886956695499e+01*V(F1118) +2.9523881204336945e+01*V(F1119) -2.4345528274663845e+01*V(F1120) +1.5198181645277144e+01*V(F1121) +4.6407211752150895e-01*V(F1122) -1.4030239693830395e+00*V(F1123) +2.8968612734388093e+00*V(F1124) -4.2231038141085522e+00*V(F1125) +4.4227315643763703e+00*V(F1126) -3.6484455269257783e+00*V(F1127) +2.2650310114362053e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1121)));
	I(F1122)<+( +1.7236954851615742e-26*V(reduced_0) -1.2545722487198356e-26*V(reduced_1) +1.8968674458059054e-03*V(F841) -5.3344260214571943e-03*V(F850) +3.1007351448872709e-02*V(F859) -8.1071093004863107e-02*V(F868) +1.3280266944228020e-01*V(F877) -1.4820116388967938e-01*V(F886) +1.1949153117369485e-01*V(F895) -8.4166396705982083e-02*V(F904) -4.8716018198417317e-02*V(F913) +1.5876720007431580e-02*V(F1001) -4.4730592030244133e-02*V(F1009) +2.5966917119019534e-01*V(F1017) -6.7873832728546135e-01*V(F1025) +1.1117172852871933e+00*V(F1033) -1.2405482244838584e+00*V(F1041) +1.0002034477026385e+00*V(F1049) -7.0470066542437104e-01*V(F1057) -4.0647969641375681e-01*V(F1065) -5.1139427095185569e-02*V(F1066) +8.2314070811703388e-02*V(F1067) -9.9788210729050877e-02*V(F1068) +9.5283483499257374e-02*V(F1069) -6.5359220226515566e-02*V(F1070) +3.1654578311401636e-02*V(F1071) -1.0470910435873381e-02*V(F1072) +1.4236836453406990e-01*V(F1073) -2.3009393378918266e-01*V(F1074) +2.7885881366128112e-01*V(F1075) -2.6627991136831997e-01*V(F1076) +1.8266917629412113e-01*V(F1077) -8.8478608014815149e-02*V(F1078) +2.9257127597997402e-02*V(F1079) -8.3349773500050761e-01*V(F1080) +1.3431914359908044e+00*V(F1081) -1.6281950360351649e+00*V(F1082) +1.5547099078631752e+00*V(F1083) -1.0664722263792714e+00*V(F1084) +5.1652557488193052e-01*V(F1085) -1.7084205755811932e-01*V(F1086) +2.1825526913309767e+00*V(F1087) -3.5150593884147554e+00*V(F1088) +4.2610836446706122e+00*V(F1089) -4.0687467160462125e+00*V(F1090) +2.7909701919131460e+00*V(F1091) -1.3517332011970111e+00*V(F1092) +4.4711280154642269e-01*V(F1093) -3.5774577275483415e+00*V(F1094) +5.7601541177196243e+00*V(F1095) -6.9827935374628600e+00*V(F1096) +6.6675892952422684e+00*V(F1097) -4.5736305629945289e+00*V(F1098) +2.2151044657593051e+00*V(F1099) -7.3270606768734303e-01*V(F1100) +3.9935572664660803e+00*V(F1101) -6.4292883031984713e+00*V(F1102) +7.7940291484325561e+00*V(F1103) -7.4421970545439251e+00*V(F1104) +5.1049583447766071e+00*V(F1105) -2.4724296790972238e+00*V(F1106) +8.1783268484370930e-01*V(F1107) -3.2203643453827273e+00*V(F1108) +5.1842269825430201e+00*V(F1109) -6.2847041650981552e+00*V(F1110) +6.0010019363347391e+00*V(F1111) -4.1163689600658468e+00*V(F1112) +1.9936340981538556e+00*V(F1113) -6.5945939705812129e-01*V(F1114) +2.2650310113495848e+00*V(F1115) -3.6484455267992111e+00*V(F1116) +4.4227315642246028e+00*V(F1117) -4.2231038139787200e+00*V(F1118) +2.8968612733663281e+00*V(F1119) -1.4030239693612152e+00*V(F1120) +4.6407211752150895e-01*V(F1121) +1.3359359025710291e+00*V(F1122) -2.1357119500411503e+00*V(F1123) +2.5903544832103265e+00*V(F1124) -2.4732690172458733e+00*V(F1125) +1.6962796511502922e+00*V(F1126) -8.2139940274219514e-01*V(F1127) +2.7187014590629394e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1122)));
	I(F1123)<+( -2.7405267476386191e-27*V(reduced_0) +2.0044390646918908e-27*V(reduced_1) -6.5624914641190793e-03*V(F841) +1.8481154365789669e-02*V(F850) -1.0731851881139319e-01*V(F859) +2.8053321165833206e-01*V(F868) -4.5950216693271612e-01*V(F877) +5.1275837742338881e-01*V(F886) -4.1341855488145923e-01*V(F895) +2.9125925823159443e-01*V(F904) +1.6813624312354133e-01*V(F913) -1.9027648214014703e-02*V(F1001) +5.3646381169944655e-02*V(F1009) -3.1126900103407906e-01*V(F1017) +8.1352507506298888e-01*V(F1025) -1.3324279958790437e+00*V(F1033) +1.4868015713413274e+00*V(F1041) -1.1987357426135847e+00*V(F1049) +8.4466575174894420e-01*V(F1057) +4.8655123218523327e-01*V(F1065) +8.2314070811591256e-02*V(F1066) -1.6467366024236632e-01*V(F1067) +2.1546442477622252e-01*V(F1068) -2.1071435392598886e-01*V(F1069) +1.5468627910116312e-01*V(F1070) -8.3183430654821131e-02*V(F1071) +3.1654578311911465e-02*V(F1072) -2.3009393378828985e-01*V(F1073) +4.6007573629494286e-01*V(F1074) -6.0276143913776559e-01*V(F1075) +5.8944372384211996e-01*V(F1076) -4.3271891270745771e-01*V(F1077) +2.3268391800369606e-01*V(F1078) -8.8478608016149388e-02*V(F1079) +1.3431914359872266e+00*V(F1080) -2.6867190594779915e+00*V(F1081) +3.5167218067464718e+00*V(F1082) -3.4391431676543043e+00*V(F1083) +2.5246991424889069e+00*V(F1084) -1.3576490566432460e+00*V(F1085) +5.1652557488994244e-01*V(F1086) -3.5150593884060988e+00*V(F1087) +7.0315467697569130e+00*V(F1088) -9.2019944042817876e+00*V(F1089) +8.9990663595010751e+00*V(F1090) -6.6062644258424861e+00*V(F1091) +3.5525281151706949e+00*V(F1092) -1.3517332012180727e+00*V(F1093) +5.7601541177058735e+00*V(F1094) -1.1523014944433543e+01*V(F1095) +1.5078657113041187e+01*V(F1096) -1.4746178309926458e+01*V(F1097) +1.0825242181627349e+01*V(F1098) -5.8213095598801345e+00*V(F1099) +2.2151044657938743e+00*V(F1100) -6.4292883031833590e+00*V(F1101) +1.2861811619295233e+01*V(F1102) -1.6829864738809324e+01*V(F1103) +1.6458798722086623e+01*V(F1104) -1.2082480053554377e+01*V(F1105) +6.4974051064912501e+00*V(F1106) -2.4724296791358391e+00*V(F1107) +5.1842269825308804e+00*V(F1108) -1.0371135583175636e+01*V(F1109) +1.3570540338319198e+01*V(F1110) -1.3271345105518527e+01*V(F1111) +9.7425538706785222e+00*V(F1112) -5.2391038509181183e+00*V(F1113) +1.9936340981849969e+00*V(F1114) -3.6484455267899909e+00*V(F1115) +7.2982322476838153e+00*V(F1116) -9.5514598044536392e+00*V(F1117) +9.3408078200281590e+00*V(F1118) -6.8571421606460774e+00*V(F1119) +3.6874302301463260e+00*V(F1120) -1.4030239693830395e+00*V(F1121) -2.1357119500411503e+00*V(F1122) +4.2763350081832483e+00*V(F1123) -5.5830920323237256e+00*V(F1124) +5.4604667984823054e+00*V(F1125) -4.0084603279611599e+00*V(F1126) +2.1557773721535041e+00*V(F1127) -8.2139940275612378e-01*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1123)));
	I(F1124)<+( +3.1265859438545569e-26*V(reduced_0) -2.2977680011517689e-26*V(reduced_1) +1.4677870163362687e-02*V(F841) -4.1359721804415620e-02*V(F850) +2.4007300961579647e-01*V(F859) -6.2750135953454367e-01*V(F868) +1.0277850648254667e+00*V(F877) -1.1468835379802977e+00*V(F886) +9.2468337545431156e-01*V(F895) -6.5150779994573538e-01*V(F904) -3.7568152510284530e-01*V(F913) +2.4010008153351942e-02*V(F1001) -6.7688275657563329e-02*V(F1009) +3.9276525498223769e-01*V(F1017) -1.0265338666582804e+00*V(F1025) +1.6813115340593410e+00*V(F1033) -1.8761111110637330e+00*V(F1041) +1.5126187018856461e+00*V(F1049) -1.0658251080187602e+00*V(F1057) -6.1403691502352009e-01*V(F1065) -9.9788210728907464e-02*V(F1066) +2.1546442477618866e-01*V(F1067) -3.1620718362214578e-01*V(F1068) +3.3408064986595815e-01*V(F1069) -2.6108696465005737e-01*V(F1070) +1.5468627910298724e-01*V(F1071) -6.5359220228195167e-02*V(F1072) +2.7885881366012405e-01*V(F1073) -6.0276143913752955e-01*V(F1074) +8.8414077442475947e-01*V(F1075) -9.3473983806429495e-01*V(F1076) +7.3045492061881589e-01*V(F1077) -4.3271891271252944e-01*V(F1078) +1.8266917629858923e-01*V(F1079) -1.6281950360305217e+00*V(F1080) +3.5167218067455410e+00*V(F1081) -5.1602421003543135e+00*V(F1082) +5.4529813110534260e+00*V(F1083) -4.2614636907118788e+00*V(F1084) +2.5246991425185388e+00*V(F1085) -1.0664722264059021e+00*V(F1086) +4.2610836446593785e+00*V(F1087) -9.2019944042795387e+00*V(F1088) +1.3503521782562846e+01*V(F1089) -1.4268145479559884e+01*V(F1090) +1.1150568036050515e+01*V(F1091) -6.6062644259200276e+00*V(F1092) +2.7909701919830625e+00*V(F1093) -6.9827935374450130e+00*V(F1094) +1.5078657113037615e+01*V(F1095) -2.2127952399224448e+01*V(F1096) +2.3379971184283324e+01*V(F1097) -1.8271548080436471e+01*V(F1098) +1.0825242181754414e+01*V(F1099) -4.5736305631092398e+00*V(F1100) +7.7940291484129451e+00*V(F1101) -1.6829864738805398e+01*V(F1102) +2.4698252887330824e+01*V(F1103) -2.6095144505541342e+01*V(F1104) +2.0393514600849674e+01*V(F1105) -1.2082480053696200e+01*V(F1106) +5.1049583449047118e+00*V(F1107) -6.2847041650823980e+00*V(F1108) +1.3570540338316045e+01*V(F1109) -1.9915248646669585e+01*V(F1110) +2.1041431267857547e+01*V(F1111) -1.6444022901494339e+01*V(F1112) +9.7425538707928716e+00*V(F1113) -4.1163689601691518e+00*V(F1114) +4.4227315642126337e+00*V(F1115) -9.5514598044512518e+00*V(F1116) +1.4016082803341902e+01*V(F1117) -1.4810096935761411e+01*V(F1118) +1.1574072661903624e+01*V(F1119) -6.8571421607265606e+00*V(F1120) +2.8968612734388093e+00*V(F1121) +2.5903544832103265e+00*V(F1122) -5.5830920323237256e+00*V(F1123) +8.2005153858372477e+00*V(F1124) -8.6543311963003600e+00*V(F1125) +6.7642536950417558e+00*V(F1126) -4.0084603280095186e+00*V(F1127) +1.6962796511958149e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1124)));
	I(F1125)<+( -1.3640509742354566e-26*V(reduced_0) +1.0071595093642707e-26*V(reduced_1) -2.2383513851063120e-02*V(F841) +6.3091844916076029e-02*V(F850) -3.6613961522086480e-01*V(F859) +9.5697020405928046e-01*V(F868) -1.5673934159712033e+00*V(F877) +1.7490041311170115e+00*V(F886) -1.4101417980036954e+00*V(F895) +9.9359234050072542e-01*V(F904) +5.7261308640282671e-01*V(F913) -2.2383513849930790e-02*V(F1001) +6.3091844912459324e-02*V(F1009) -3.6613961520101673e-01*V(F1017) +9.5697020400788846e-01*V(F1025) -1.5673934158873273e+00*V(F1033) +1.7490041310235764e+00*V(F1041) -1.4101417979283908e+00*V(F1049) +9.9359234044720290e-01*V(F1057) +5.7261308637626662e-01*V(F1065) +9.5283483499124175e-02*V(F1066) -2.1071435392595231e-01*V(F1067) +3.3408064986594260e-01*V(F1068) -3.9273913787332804e-01*V(F1069) +3.3408064986925134e-01*V(F1070) -2.1071435393024557e-01*V(F1071) +9.5283483502256586e-02*V(F1072) -2.6627991136724211e-01*V(F1073) +5.8944372384184540e-01*V(F1074) -9.3473983806420724e-01*V(F1075) +1.0983285024371141e+00*V(F1076) -9.3473983807353167e-01*V(F1077) +5.8944372385399180e-01*V(F1078) -2.6627991137634882e-01*V(F1079) +1.5547099078588487e+00*V(F1080) -3.4391431676532109e+00*V(F1081) +5.4529813110530885e+00*V(F1082) -6.4095175505051181e+00*V(F1083) +5.4529813111071848e+00*V(F1084) -3.4391431677235706e+00*V(F1085) +1.5547099079108908e+00*V(F1086) -4.0687467160357436e+00*V(F1087) +8.9990663594984301e+00*V(F1088) -1.4268145479559065e+01*V(F1089) +1.6772220343711307e+01*V(F1090) -1.4268145479700467e+01*V(F1091) +8.9990663596822902e+00*V(F1092) -4.0687467161714279e+00*V(F1093) +6.6675892952256381e+00*V(F1094) -1.4746178309922257e+01*V(F1095) +2.3379971184282027e+01*V(F1096) -2.7484000081754814e+01*V(F1097) +2.3379971184513625e+01*V(F1098) -1.4746178310223380e+01*V(F1099) +6.6675892954476685e+00*V(F1100) -7.4421970545256482e+00*V(F1101) +1.6458798722082012e+01*V(F1102) -2.6095144505539931e+01*V(F1103) +3.0676262008485715e+01*V(F1104) -2.6095144505798373e+01*V(F1105) +1.6458798722418017e+01*V(F1106) -7.4421970547732919e+00*V(F1107) +6.0010019363200566e+00*V(F1108) -1.3271345105514824e+01*V(F1109) +2.1041431267856417e+01*V(F1110) -2.4735510387278335e+01*V(F1111) +2.1041431268064784e+01*V(F1112) -1.3271345105785731e+01*V(F1113) +6.0010019365196996e+00*V(F1114) -4.2231038139675663e+00*V(F1115) +9.3408078200253488e+00*V(F1116) -1.4810096935760555e+01*V(F1117) +1.7408969996891127e+01*V(F1118) -1.4810096935907362e+01*V(F1119) +9.3408078202162628e+00*V(F1120) -4.2231038141085522e+00*V(F1121) -2.4732690172458733e+00*V(F1122) +5.4604667984823054e+00*V(F1123) -8.6543311963003600e+00*V(F1124) +1.0182205907775675e+01*V(F1125) -8.6543311963874299e+00*V(F1126) +5.4604667985950135e+00*V(F1127) -2.4732690173269072e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1125)));
	I(F1126)<+( +3.1804973272035635e-26*V(reduced_0) -2.3591246024116002e-26*V(reduced_1) +2.4010008154616111e-02*V(F841) -6.7688275661591191e-02*V(F850) +3.9276525500436560e-01*V(F859) -1.0265338667155854e+00*V(F868) +1.6813115341528742e+00*V(F877) -1.8761111111679301e+00*V(F886) +1.5126187019696251e+00*V(F895) -1.0658251080784373e+00*V(F904) -6.1403691505323332e-01*V(F913) +1.4677870162672531e-02*V(F1001) -4.1359721802201772e-02*V(F1009) +2.4007300960366965e-01*V(F1017) -6.2750135950315467e-01*V(F1025) +1.0277850647742433e+00*V(F1033) -1.1468835379232403e+00*V(F1041) +9.2468337540832657e-01*V(F1049) -6.5150779991304153e-01*V(F1057) -3.7568152508672376e-01*V(F1065) -6.5359220226430759e-02*V(F1066) +1.5468627910113769e-01*V(F1067) -2.6108696465004494e-01*V(F1068) +3.3408064986924346e-01*V(F1069) -3.1620718362783679e-01*V(F1070) +2.1546442478175110e-01*V(F1071) -9.9788210732550287e-02*V(F1072) +1.8266917629343482e-01*V(F1073) -4.3271891270726703e-01*V(F1074) +7.3045492061873896e-01*V(F1075) -9.3473983807351113e-01*V(F1076) +8.8414077444076200e-01*V(F1077) -6.0276143915322422e-01*V(F1078) +2.7885881367068499e-01*V(F1079) -1.0664722263765165e+00*V(F1080) +2.5246991424881475e+00*V(F1081) -4.2614636907115777e+00*V(F1082) +5.4529813111071181e+00*V(F1083) -5.1602421004473422e+00*V(F1084) +3.5167218068365611e+00*V(F1085) -1.6281950360909541e+00*V(F1086) +2.7909701919064798e+00*V(F1087) -6.6062644258406484e+00*V(F1088) +1.1150568036049791e+01*V(F1089) -1.4268145479700310e+01*V(F1090) +1.3503521782806082e+01*V(F1091) -9.2019944045174338e+00*V(F1092) +4.2610836448169698e+00*V(F1093) -4.5736305629839427e+00*V(F1094) +1.0825242181624436e+01*V(F1095) -1.8271548080435320e+01*V(F1096) +2.3379971184513391e+01*V(F1097) -2.2127952399622902e+01*V(F1098) +1.5078657113427260e+01*V(F1099) -6.9827935377029124e+00*V(F1100) +5.1049583447649693e+00*V(F1101) -1.2082480053551174e+01*V(F1102) +2.0393514600848402e+01*V(F1103) -2.6095144505798103e+01*V(F1104) +2.4698252887775475e+01*V(F1105) -1.6829864739240197e+01*V(F1106) +7.7940291487006093e+00*V(F1107) -4.1163689600564979e+00*V(F1108) +9.7425538706759429e+00*V(F1109) -1.6444022901493323e+01*V(F1110) +2.1041431268064571e+01*V(F1111) -1.9915248647028104e+01*V(F1112) +1.3570540338666612e+01*V(F1113) -6.2847041653143085e+00*V(F1114) +2.8968612733592258e+00*V(F1115) -6.8571421606441216e+00*V(F1116) +1.1574072661902859e+01*V(F1117) -1.4810096935907207e+01*V(F1118) +1.4016082803594434e+01*V(F1119) -9.5514598046982577e+00*V(F1120) +4.4227315643763703e+00*V(F1121) +1.6962796511502922e+00*V(F1122) -4.0084603279611599e+00*V(F1123) +6.7642536950417558e+00*V(F1124) -8.6543311963874299e+00*V(F1125) +8.2005153859874866e+00*V(F1126) -5.5830920324698754e+00*V(F1127) +2.5903544833046599e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1126)));
	I(F1127)<+( -2.8358578521551303e-27*V(reduced_0) +2.1129354936143150e-27*V(reduced_1) -1.9027648215034065e-02*V(F841) +5.3646381173185154e-02*V(F850) -3.1126900105189803e-01*V(F859) +8.1352507510914296e-01*V(F868) -1.3324279959543812e+00*V(F877) +1.4868015714252563e+00*V(F886) -1.1987357426812286e+00*V(F895) +8.4466575179700609e-01*V(F904) +4.8655123220922386e-01*V(F913) -6.5624914638541445e-03*V(F1001) +1.8481154364931477e-02*V(F1009) -1.0731851880671232e-01*V(F1017) +2.8053321164622497e-01*V(F1025) -4.5950216691296475e-01*V(F1033) +5.1275837740139063e-01*V(F1041) -4.1341855486373025e-01*V(F1049) +2.9125925821898130e-01*V(F1057) +1.6813624311741415e-01*V(F1065) +3.1654578311366449e-02*V(F1066) -8.3183430654810181e-02*V(F1067) +1.5468627910298155e-01*V(F1068) -2.1071435393024227e-01*V(F1069) +2.1546442478174718e-01*V(F1070) -1.6467366024721192e-01*V(F1071) +8.2314070814617279e-02*V(F1072) -8.8478608014532237e-02*V(F1073) +2.3268391800362090e-01*V(F1074) -4.3271891271251123e-01*V(F1075) +5.8944372385400967e-01*V(F1076) -6.0276143915325175e-01*V(F1077) +4.6007573630857362e-01*V(F1078) -2.3009393379703788e-01*V(F1079) +5.1652557488079542e-01*V(F1080) -1.3576490566429493e+00*V(F1081) +2.5246991425184766e+00*V(F1082) -3.4391431677236604e+00*V(F1083) +3.5167218068366966e+00*V(F1084) -2.6867190595572086e+00*V(F1085) +1.3431914360373374e+00*V(F1086) -1.3517332011942649e+00*V(F1087) +3.5525281151699777e+00*V(F1088) -6.6062644259198802e+00*V(F1089) +8.9990663596825069e+00*V(F1090) -9.2019944045177624e+00*V(F1091) +7.0315467699640264e+00*V(F1092) -3.5150593885368027e+00*V(F1093) +2.2151044657549424e+00*V(F1094) -5.8213095598789968e+00*V(F1095) +1.0825242181754183e+01*V(F1096) -1.4746178310223728e+01*V(F1097) +1.5078657113427790e+01*V(F1098) -1.1523014944772813e+01*V(F1099) +5.7601541179197842e+00*V(F1100) -2.4724296790924289e+00*V(F1101) +6.4974051064899978e+00*V(F1102) -1.2082480053695940e+01*V(F1103) +1.6458798722418397e+01*V(F1104) -1.6829864739240779e+01*V(F1105) +1.2861811619673835e+01*V(F1106) -6.4292883034219672e+00*V(F1107) +1.9936340981500038e+00*V(F1108) -5.2391038509171119e+00*V(F1109) +9.7425538707926655e+00*V(F1110) -1.3271345105786040e+01*V(F1111) +1.3570540338667083e+01*V(F1112) -1.0371135583480898e+01*V(F1113) +5.1842269827232412e+00*V(F1114) -1.4030239693582895e+00*V(F1115) +3.6874302301455648e+00*V(F1116) -6.8571421607264078e+00*V(F1117) +9.3408078202165026e+00*V(F1118) -9.5514598046986237e+00*V(F1119) +7.2982322478988459e+00*V(F1120) -3.6484455269257783e+00*V(F1121) -8.2139940274219514e-01*V(F1122) +2.1557773721535041e+00*V(F1123) -4.0084603280095186e+00*V(F1124) +5.4604667985950135e+00*V(F1125) -5.5830920324698754e+00*V(F1126) +4.2763350083108866e+00*V(F1127) -2.1357119501194934e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1127)));
	I(F1128)<+( +1.8144243985988727e-26*V(reduced_0) -1.3578309191299434e-26*V(reduced_1) +1.5876720008207626e-02*V(F841) -4.4730592032691190e-02*V(F850) +2.5966917120369576e-01*V(F859) -6.7873832732045014e-01*V(F868) +1.1117172853443182e+00*V(F877) -1.2405482245475050e+00*V(F886) +1.0002034477539377e+00*V(F895) -7.0470066546079990e-01*V(F904) -4.0647969643211668e-01*V(F913) +1.8968674457551162e-03*V(F1001) -5.3344260212850186e-03*V(F1009) +3.1007351447952022e-02*V(F1017) -8.1071093002490172e-02*V(F1025) +1.3280266943841409e-01*V(F1033) -1.4820116388537638e-01*V(F1041) +1.1949153117022747e-01*V(F1049) -8.4166396703507076e-02*V(F1057) -4.8716018197298407e-02*V(F1065) -1.0470910435865267e-02*V(F1066) +3.1654578311910687e-02*V(F1067) -6.5359220228198456e-02*V(F1068) +9.5283483502263344e-02*V(F1069) -9.9788210732557947e-02*V(F1070) +8.2314070814622733e-02*V(F1071) -5.1139427097136467e-02*V(F1072) +2.9257127597937218e-02*V(F1073) -8.8478608016167096e-02*V(F1074) +1.8266917629867319e-01*V(F1075) -2.6627991137649504e-01*V(F1076) +2.7885881367084919e-01*V(F1077) -2.3009393379717413e-01*V(F1078) +1.4236836453957313e-01*V(F1079) -1.7084205755787985e-01*V(F1080) +5.1652557489002315e-01*V(F1081) -1.0664722264062618e+00*V(F1082) +1.5547099079115132e+00*V(F1083) -1.6281950360916542e+00*V(F1084) +1.3431914360379211e+00*V(F1085) -8.3349773503242985e-01*V(F1086) +4.4711280154584349e-01*V(F1087) -1.3517332012182692e+00*V(F1088) +2.7909701919839369e+00*V(F1089) -4.0687467161729405e+00*V(F1090) +4.2610836448186689e+00*V(F1091) -3.5150593885382211e+00*V(F1092) +2.1825526914144038e+00*V(F1093) -7.3270606768642332e-01*V(F1094) +2.2151044657941870e+00*V(F1095) -4.5736305631106298e+00*V(F1096) +6.6675892954500720e+00*V(F1097) -6.9827935377056125e+00*V(F1098) +5.7601541179220384e+00*V(F1099) -3.5774577276849788e+00*V(F1100) +8.1783268484269855e-01*V(F1101) -2.4724296791361824e+00*V(F1102) +5.1049583449062412e+00*V(F1103) -7.4421970547759360e+00*V(F1104) +7.7940291487035820e+00*V(F1105) -6.4292883034244488e+00*V(F1106) +3.9935572666185450e+00*V(F1107) -6.5945939705730949e-01*V(F1108) +1.9936340981852732e+00*V(F1109) -4.1163689601703819e+00*V(F1110) +6.0010019365218268e+00*V(F1111) -6.2847041653166977e+00*V(F1112) +5.1842269827252361e+00*V(F1113) -3.2203643455056512e+00*V(F1114) +4.6407211752089272e-01*V(F1115) -1.4030239693832525e+00*V(F1116) +2.8968612734397516e+00*V(F1117) -4.2231038141101802e+00*V(F1118) +4.4227315643781999e+00*V(F1119) -3.6484455269273059e+00*V(F1120) +2.2650310114362053e+00*V(F1121) +2.7187014590629394e-01*V(F1122) -8.2139940275612378e-01*V(F1123) +1.6962796511958149e+00*V(F1124) -2.4732690173269072e+00*V(F1125) +2.5903544833046599e+00*V(F1126) -2.1357119501194934e+00*V(F1127) +1.3359359026227662e+00*V(F1128))+ ddt(( +1.0000000000000000e-03*V(Vol_F1128)));
	I(F1129)<+( +1.6171301011805778e-12*V(reduced_0) -6.6471847664525553e-11*V(reduced_1) +2.1218123069540765e-01*V(F1129) -2.2978930367905756e-04*V(F1130) +2.0632419465739822e-04*V(F1131) -2.6991596144005270e-04*V(F1132) +2.7150868034501281e-04*V(F1133) -2.0034567744942839e-04*V(F1134) +1.0900943000565828e-04*V(F1135) -4.4966273201376265e-05*V(F1136) +2.8204506864677460e-06*V(F1137) +3.6169917352708225e-01*V(F1138) -1.2203744982370892e-03*V(F1139) +1.5265561854387454e-03*V(F1140) -1.9174208546956408e-03*V(F1141) +1.7691165199216149e-03*V(F1142) -1.1394259373287874e-03*V(F1143) +4.9143500087880086e-04*V(F1144) -1.2958125821309818e-04*V(F1145) +2.3451838612504325e-05*V(F1146) -5.1402341882084823e-01*V(F1147) +1.6683199287221302e-03*V(F1148) -2.0759261374266929e-03*V(F1149) +2.6089078611074021e-03*V(F1150) -2.4101562188680475e-03*V(F1151) +1.5557397178458322e-03*V(F1152) -6.7404527484254614e-04*V(F1153) +1.7992396063179592e-04*V(F1154) -3.1844387902975713e-05*V(F1155) +6.3746481420575452e-01*V(F1156) -2.0766710150908084e-03*V(F1157) +2.5853770183461096e-03*V(F1158) -3.2489796989625857e-03*V(F1159) +3.0010957472982932e-03*V(F1160) -1.9367677927399928e-03*V(F1161) +8.3875958063318423e-04*V(F1162) -2.2362611953607696e-04*V(F1163) +3.9665046067869551e-05*V(F1164) -5.7110275051246995e-01*V(F1165) +1.8767806733142531e-03*V(F1166) -2.3393245184499759e-03*V(F1167) +2.9393978040474127e-03*V(F1168) -2.7143538346261274e-03*V(F1169) +1.7508346669887706e-03*V(F1170) -7.5745524302917814e-04*V(F1171) +2.0139015164795227e-04*V(F1172) -3.5902216976314983e-05*V(F1173) +3.4848782997234462e-01*V(F1174) -1.1642450107248550e-03*V(F1175) +1.4544252637672904e-03*V(F1176) -1.8270759280316275e-03*V(F1177) +1.6862909582700438e-03*V(F1178) -1.0866836010238342e-03*V(F1179) +4.6922186475247690e-04*V(F1180) -1.2410789960684370e-04*V(F1181) +2.2335460065069827e-05*V(F1182) -1.3314691679046503e-01*V(F1183) +4.6264243737508052e-04*V(F1184) -5.8094177966101009e-04*V(F1185) +7.2939268987242214e-04*V(F1186) -6.7236059936655356e-04*V(F1187) +4.3234469706375733e-04*V(F1188) -1.8585023395867800e-04*V(F1189) +4.8559637520074512e-05*V(F1190) -8.9343477604993333e-06*V(F1191) +2.2793247463307471e-02*V(F1192) -9.3637770329427672e-05*V(F1193) +1.1990985997292429e-04*V(F1194) -1.5024321163144871e-04*V(F1195) +1.3785270902548228e-04*V(F1196) -8.7913248542874944e-05*V(F1197) +3.7142722946859134e-05*V(F1198) -9.2379613053484728e-06*V(F1199) +1.8540892493750217e-06*V(F1200) -8.1618219915910156e-03*V(F1201) +2.6240007055547135e-05*V(F1202) -3.2607821877973225e-05*V(F1203) +4.0985446699647237e-05*V(F1204) -3.7875113416434019e-05*V(F1205) +2.4461740597473327e-05*V(F1206) -1.0610425158659714e-05*V(F1207) +2.8408644185701320e-06*V(F1208) -5.0001210058576292e-07*V(F1209) +7.3803523872629333e-03*V(F1289) +1.2817649434080765e-02*V(F1297) -1.8190037986081629e-02*V(F1305) +2.2561315652388624e-02*V(F1313) -2.0218928185331376e-02*V(F1321) +1.2344997404166410e-02*V(F1329) -4.7235641706852224e-03*V(F1337) +8.1421589694075146e-04*V(F1345) -2.8873010746584580e-04*V(F1353) -4.8716018199241637e-02*V(F1354) +1.6813624312480685e-01*V(F1355) -3.7568152510415548e-01*V(F1356) +5.7261308640360475e-01*V(F1357) -6.1403691505326086e-01*V(F1358) +4.8655123220878060e-01*V(F1359) -4.0647969643090870e-01*V(F1360) -8.4166396707423610e-02*V(F1361) +2.9125925823398791e-01*V(F1362) -6.5150779994850905e-01*V(F1363) +9.9359234050288092e-01*V(F1364) -1.0658251080793775e+00*V(F1365) +8.4466575179696479e-01*V(F1366) -7.0470066545939802e-01*V(F1367) +1.1949153117569872e-01*V(F1368) -4.1341855488469886e-01*V(F1369) +9.2468337545789425e-01*V(F1370) -1.4101417980062121e+00*V(F1371) +1.5126187019703774e+00*V(F1372) -1.1987357426807062e+00*V(F1373) +1.0002034477515567e+00*V(F1374) -1.4820116389213012e-01*V(F1375) +5.1275837742728847e-01*V(F1376) -1.1468835379844760e+00*V(F1377) +1.7490041311197293e+00*V(F1378) -1.8761111111684292e+00*V(F1379) +1.4868015714242668e+00*V(F1380) -1.2405482245442669e+00*V(F1381) +1.3280266944446678e-01*V(F1382) -4.5950216693617940e-01*V(F1383) +1.0277850648291424e+00*V(F1384) -1.5673934159735337e+00*V(F1385) +1.6813115341532094e+00*V(F1386) -1.3324279959534058e+00*V(F1387) +1.1117172853413442e+00*V(F1388) -8.1071093006184008e-02*V(F1389) +2.8053321166040085e-01*V(F1390) -6.2750135953668562e-01*V(F1391) +9.5697020406054822e-01*V(F1392) -1.0265338667156241e+00*V(F1393) +8.1352507510841554e-01*V(F1394) -6.7873832731852701e-01*V(F1395) +3.1007351449372052e-02*V(F1396) -1.0731851881216666e-01*V(F1397) +2.4007300961657654e-01*V(F1398) -3.6613961522128963e-01*V(F1399) +3.9276525500431558e-01*V(F1400) -3.1126900105156879e-01*V(F1401) +2.5966917120291932e-01*V(F1402) -5.3344260215322670e-03*V(F1403) +1.8481154365886789e-02*V(F1404) -4.1359721804469299e-02*V(F1405) +6.3091844916026180e-02*V(F1406) -6.7688275661450609e-02*V(F1407) +5.3646381173024081e-02*V(F1408) -4.4730592032471830e-02*V(F1409) +1.8968674458429351e-03*V(F1410) -6.5624914641861307e-03*V(F1411) +1.4677870163453972e-02*V(F1412) -2.2383513851155300e-02*V(F1413) +2.4010008154683876e-02*V(F1414) -1.9027648215069790e-02*V(F1415) +1.5876720008205593e-02*V(F1416))+ ddt(( +1.0000000000000000e-03*V(Vol_F1129)));
	I(F1130)<+( +9.6275652535189394e-12*V(reduced_0) -3.9573937214141738e-10*V(reduced_1) -2.2978930367905756e-04*V(F1129) +3.8117561396398643e-03*V(F1130) -4.4514068865956491e-03*V(F1131) +5.5416390854221937e-03*V(F1132) -5.2742547627900914e-03*V(F1133) +3.5894236219729488e-03*V(F1134) -1.7225618257608612e-03*V(F1135) +5.8849704229418595e-04*V(F1136) -4.4966273201859996e-05*V(F1137) -1.2203744982443754e-03*V(F1138) +1.0854510125987314e-03*V(F1139) -3.3071380033887357e-03*V(F1140) +3.8746341783174056e-03*V(F1141) -3.7156728698022863e-03*V(F1142) +2.5750783556695573e-03*V(F1143) -1.2618433303790999e-03*V(F1144) +4.0008096577248659e-04*V(F1145) -1.2958125821365600e-04*V(F1146) +1.6683199287320476e-03*V(F1147) -1.9713287999449411e-03*V(F1148) +5.0384052383839325e-03*V(F1149) -5.9470857099384686e-03*V(F1150) +5.6976902290870367e-03*V(F1151) -3.9397872604738727e-03*V(F1152) +1.9256702956010538e-03*V(F1153) -6.1627578959688983e-04*V(F1154) +1.7992396063259665e-04*V(F1155) -2.0766710151032537e-03*V(F1156) +2.3946602764771197e-03*V(F1157) -6.2088272100483096e-03*V(F1158) +7.3237891209153669e-03*V(F1159) -7.0172455514756751e-03*V(F1160) +4.8531839037524319e-03*V(F1161) -2.3726485534941322e-03*V(F1162) +7.5870076612849448e-04*V(F1163) -2.2362611953706258e-04*V(F1164) +1.8767806733256160e-03*V(F1165) -2.0394903559343451e-03*V(F1166) +5.4788750970297291e-03*V(F1167) -6.4525304868243783e-03*V(F1168) +6.1836997392301094e-03*V(F1169) -4.2787459228942051e-03*V(F1170) +2.0929481965508601e-03*V(F1171) -6.6793683674558823e-04*V(F1172) +2.0139015164882847e-04*V(F1173) -1.1642450107320398e-03*V(F1174) +1.1208679120906547e-03*V(F1175) -3.2456072344726910e-03*V(F1176) +3.8102662270874188e-03*V(F1177) -3.6529986322895130e-03*V(F1178) +2.5300864571548521e-03*V(F1179) -1.2389368147688658e-03*V(F1180) +3.9381986815273433e-04*V(F1181) -1.2410789960737203e-04*V(F1182) +4.6264243737809623e-04*V(F1183) -3.1248944501792030e-04*V(F1184) +1.1486540959501138e-03*V(F1185) -1.3368026069054684e-03*V(F1186) +1.2830574247808142e-03*V(F1187) -8.9100511502750537e-04*V(F1188) +4.3760864886681442e-04*V(F1189) -1.3758649432864972e-04*V(F1190) +4.8559637520272210e-05*V(F1191) -9.3637770330299005e-05*V(F1192) -4.0306966878594072e-05*V(F1193) -1.2257757157703352e-04*V(F1194) +1.3242936452434082e-04*V(F1195) -1.2836784278025650e-04*V(F1196) +9.1217371107110771e-05*V(F1197) -4.5943240185378792e-05*V(F1198) +1.3116174362617924e-05*V(F1199) -9.2379613053835061e-06*V(F1200) +2.6240007055746422e-05*V(F1201) -3.2926095640237500e-05*V(F1202) +8.1284118987310852e-05*V(F1203) -9.6099672713044601e-05*V(F1204) +9.2050681535022985e-05*V(F1205) -6.3619145474512023e-05*V(F1206) +3.1078179641162869e-05*V(F1207) -9.9661963914269221e-06*V(F1208) +2.8408644185896362e-06*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1130)));
	I(F1131)<+( -1.5173880019419231e-12*V(reduced_0) +6.2371966262595062e-11*V(reduced_1) +2.0632419465739827e-04*V(F1129) -4.4514068865956491e-03*V(F1130) +9.3351664268290814e-03*V(F1131) -1.0807802604600415e-02*V(F1132) +1.0622334138960800e-02*V(F1133) -7.7874183130870545e-03*V(F1134) +4.2113458293595411e-03*V(F1135) -1.7225618257642346e-03*V(F1136) +1.0900943000806202e-04*V(F1137) +1.5265561854483098e-03*V(F1138) -3.3071380034038608e-03*V(F1139) +6.2178695576308148e-03*V(F1140) -9.4387201873460565e-03*V(F1141) +9.1817270865482744e-03*V(F1142) -6.7500531792754259e-03*V(F1143) +3.6080016415519054e-03*V(F1144) -1.2618433303869707e-03*V(F1145) +4.9143500088193919e-04*V(F1146) -2.0759261374396955e-03*V(F1147) +5.0384052384047232e-03*V(F1148) -9.6034097868915435e-03*V(F1149) +1.4123535683509800e-02*V(F1150) -1.3753688703401802e-02*V(F1151) +1.0108249650125724e-02*V(F1152) -5.4096085231328450e-03*V(F1153) +1.9256702956120116e-03*V(F1154) -6.7404527484702032e-04*V(F1155) +2.5853770183624238e-03*V(F1156) -6.2088272100744701e-03*V(F1157) +1.1820062175025616e-02*V(F1158) -1.7432358276560249e-02*V(F1159) +1.6974233697981279e-02*V(F1160) -1.2475508738179850e-02*V(F1161) +6.6757573013720333e-03*V(F1162) -2.3726485535077190e-03*V(F1163) +8.3875958063870163e-04*V(F1164) -2.3393245184648703e-03*V(F1165) +5.4788750970536232e-03*V(F1166) -1.0400157501387114e-02*V(F1167) +1.5442306066511471e-02*V(F1168) -1.5033015799624358e-02*V(F1169) +1.1049467580238861e-02*V(F1170) -5.9111151681151735e-03*V(F1171) +2.0929481965630652e-03*V(F1172) -7.5745524303409413e-04*V(F1173) +1.4544252637767095e-03*V(F1174) -3.2456072344877749e-03*V(F1175) +6.1250343141759731e-03*V(F1176) -9.2182374805827600e-03*V(F1177) +8.9698215299436976e-03*V(F1178) -6.5937546595639298e-03*V(F1179) +3.5256136444495392e-03*V(F1180) -1.2389368147763598e-03*V(F1181) +4.6922186475545423e-04*V(F1182) -5.8094177966496743e-04*V(F1183) +1.1486540959563878e-03*V(F1184) -2.1331166577117609e-03*V(F1185) +3.3303652293845010e-03*V(F1186) -3.2367015538009953e-03*V(F1187) +2.3800946269803597e-03*V(F1188) -1.2708543266712860e-03*V(F1189) +4.3760864886972572e-04*V(F1190) -1.8585023395980139e-04*V(F1191) +1.1990985997407885e-04*V(F1192) -1.2257757157869094e-04*V(F1193) +1.9736926770208199e-04*V(F1194) -4.1482517558944149e-04*V(F1195) +3.9980286225129981e-04*V(F1196) -2.9466365067722301e-04*V(F1197) +1.5582810368363907e-04*V(F1198) -4.5943240185933002e-05*V(F1199) +3.7142722947060816e-05*V(F1200) -3.2607821878243862e-05*V(F1201) +8.1284118987597732e-05*V(F1202) -1.5539227965354107e-04*V(F1203) +2.2694770947967867e-04*V(F1204) -2.2105763917774579e-04*V(F1205) +1.6245537981271108e-04*V(F1206) -8.6964610646323156e-05*V(F1207) +3.1078179641363365e-05*V(F1208) -1.0610425158761604e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1131)));
	I(F1132)<+( +1.7162181538875661e-11*V(reduced_0) -7.0544844599097683e-10*V(reduced_1) -2.6991596144005270e-04*V(F1129) +5.5416390854221937e-03*V(F1130) -1.0807802604600415e-02*V(F1131) +1.6666397600241103e-02*V(F1132) -1.6488858080973865e-02*V(F1133) +1.2980437300762506e-02*V(F1134) -7.7874183130993199e-03*V(F1135) +3.5894236219841933e-03*V(F1136) -2.0034567745551572e-04*V(F1137) -1.9174208547075356e-03*V(F1138) +3.8746341783341613e-03*V(F1139) -9.4387201873566608e-03*V(F1140) +1.3105908237420819e-02*V(F1141) -1.4883869880721925e-02*V(F1142) +1.1544565643868123e-02*V(F1143) -6.7500531793007268e-03*V(F1144) +2.5750783556946462e-03*V(F1145) -1.1394259373370594e-03*V(F1146) +2.6089078611235697e-03*V(F1147) -5.9470857099614676e-03*V(F1148) +1.4123535683524462e-02*V(F1149) -1.9835138797072025e-02*V(F1150) +2.2196482777209571e-02*V(F1151) -1.7242346713997127e-02*V(F1152) +1.0108249650161289e-02*V(F1153) -3.9397872605089071e-03*V(F1154) +1.5557397178576047e-03*V(F1155) -3.2489796989828698e-03*V(F1156) +7.3237891209442909e-03*V(F1157) -1.7432358276578717e-02*V(F1158) +2.4457185035967239e-02*V(F1159) -2.7404915772830437e-02*V(F1160) +2.1285413102239362e-02*V(F1161) -1.2475508738223964e-02*V(F1162) +4.8531839037958789e-03*V(F1163) -1.9367677927545153e-03*V(F1164) +2.9393978040659296e-03*V(F1165) -6.4525304868507964e-03*V(F1166) +1.5442306066528346e-02*V(F1167) -2.1612346859860482e-02*V(F1168) +2.4294049093156446e-02*V(F1169) -1.8863101486133613e-02*V(F1170) +1.1049467580278463e-02*V(F1171) -4.2787459229332242e-03*V(F1172) +1.7508346670017218e-03*V(F1173) -1.8270759280433365e-03*V(F1174) +3.8102662271041012e-03*V(F1175) -9.2182374805934077e-03*V(F1176) +1.2839021189401858e-02*V(F1177) -1.4523087772934436e-02*V(F1178) +1.1269245558821412e-02*V(F1179) -6.5937546595881951e-03*V(F1180) +2.5300864571787883e-03*V(F1181) -1.0866836010316877e-03*V(F1182) +7.2939268987734388e-04*V(F1183) -1.3368026069124170e-03*V(F1184) +3.3303652293889025e-03*V(F1185) -4.5787544542734669e-03*V(F1186) +5.2668379834506385e-03*V(F1187) -4.0799434022085841e-03*V(F1188) +2.3800946269897224e-03*V(F1189) -8.9100511503678625e-04*V(F1190) +4.3234469706672865e-04*V(F1191) -1.5024321163288810e-04*V(F1192) +1.3242936452620511e-04*V(F1193) -4.1482517559053892e-04*V(F1194) +5.1913996808285352e-04*V(F1195) -6.7311326043450147e-04*V(F1196) +5.1555244465913337e-04*V(F1197) -2.9466365067890910e-04*V(F1198) +9.1217371108849804e-05*V(F1199) -8.7913248543410201e-05*V(F1200) +4.0985446699986762e-05*V(F1201) -9.6099672713385745e-05*V(F1202) +2.2694770947982550e-04*V(F1203) -3.1953312875749641e-04*V(F1204) +3.5640058388242580e-04*V(F1205) -2.7694707012890007e-04*V(F1206) +1.6245537981329208e-04*V(F1207) -6.3619145475136618e-05*V(F1208) +2.4461740597735483e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1132)));
	I(F1133)<+( -7.4234283714636036e-12*V(reduced_0) +3.0513871425446998e-10*V(reduced_1) +2.7150868034501281e-04*V(F1129) -5.2742547627900914e-03*V(F1130) +1.0622334138960800e-02*V(F1131) -1.6488858080973865e-02*V(F1132) +2.0344204240260552e-02*V(F1133) -1.6488858080996285e-02*V(F1134) +1.0622334138989430e-02*V(F1135) -5.2742547628101509e-03*V(F1136) +2.7150868035494800e-04*V(F1137) +1.7691165199324429e-03*V(F1138) -3.7156728698173411e-03*V(F1139) +9.1817270865563200e-03*V(F1140) -1.4883869880730852e-02*V(F1141) +1.6607710640790228e-02*V(F1142) -1.4883869880767219e-02*V(F1143) +9.1817270866072845e-03*V(F1144) -3.7156728698467690e-03*V(F1145) +1.7691165199352496e-03*V(F1146) -2.4101562188827614e-03*V(F1147) +5.6976902291076886e-03*V(F1148) -1.3753688703412896e-02*V(F1149) +2.2196482777221933e-02*V(F1150) -2.5030173100814266e-02*V(F1151) +2.2196482777273357e-02*V(F1152) -1.3753688703484762e-02*V(F1153) +5.6976902291491867e-03*V(F1154) -2.4101562188874478e-03*V(F1155) +3.0010957473167532e-03*V(F1156) -7.0172455515016482e-03*V(F1157) +1.6974233697995257e-02*V(F1158) -2.7404915772846018e-02*V(F1159) +3.0874272979572993e-02*V(F1160) -2.7404915772909568e-02*V(F1161) +1.6974233698084224e-02*V(F1162) -7.0172455515527532e-03*V(F1163) +3.0010957473222350e-03*V(F1164) -2.7143538346429807e-03*V(F1165) +6.1836997392538335e-03*V(F1166) -1.5033015799637135e-02*V(F1167) +2.4294049093170681e-02*V(F1168) -2.7307439061984049e-02*V(F1169) +2.4294049093227469e-02*V(F1170) -1.5033015799716769e-02*V(F1171) +6.1836997392993292e-03*V(F1172) -2.7143538346474805e-03*V(F1173) +1.6862909582807015e-03*V(F1174) -3.6529986323044919e-03*V(F1175) +8.9698215299517485e-03*V(F1176) -1.4523087772943416e-02*V(F1177) +1.6251171047078863e-02*V(F1178) -1.4523087772977936e-02*V(F1179) +8.9698215300003034e-03*V(F1180) -3.6529986323319691e-03*V(F1181) +1.6862909582829964e-03*V(F1182) -6.7236059937103348e-04*V(F1183) +1.2830574247870571e-03*V(F1184) -3.2367015538043360e-03*V(F1185) +5.2668379834543456e-03*V(F1186) -5.8234428633664164e-03*V(F1187) +5.2668379834674090e-03*V(F1188) -3.2367015538228459e-03*V(F1189) +1.2830574247972705e-03*V(F1190) -6.7236059937145643e-04*V(F1191) +1.3785270902679349e-04*V(F1192) -1.2836784278193780e-04*V(F1193) +3.9980286225214760e-04*V(F1194) -6.7311326043540635e-04*V(F1195) +6.8441402778894448e-04*V(F1196) -6.7311326043749365e-04*V(F1197) +3.9980286225522728e-04*V(F1198) -1.2836784278332736e-04*V(F1199) +1.3785270902636463e-04*V(F1200) -3.7875113416743810e-05*V(F1201) +9.2050681535334802e-05*V(F1202) -2.2105763917787050e-04*V(F1203) +3.5640058388253405e-04*V(F1204) -4.0284946553157400e-04*V(F1205) +3.5640058388344543e-04*V(F1206) -2.2105763917909120e-04*V(F1207) +9.2050681536118571e-05*V(F1208) -3.7875113416861615e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1133)));
	I(F1134)<+( +1.7162181538868921e-11*V(reduced_0) -7.0544844599069786e-10*V(reduced_1) -2.0034567744942839e-04*V(F1129) +3.5894236219729488e-03*V(F1130) -7.7874183130870545e-03*V(F1131) +1.2980437300762506e-02*V(F1132) -1.6488858080996285e-02*V(F1133) +1.6666397600279693e-02*V(F1134) -1.0807802604637434e-02*V(F1135) +5.5416390854454963e-03*V(F1136) -2.6991596145107058e-04*V(F1137) -1.1394259373356216e-03*V(F1138) +2.5750783556791916e-03*V(F1139) -6.7500531792811184e-03*V(F1140) +1.1544565643874362e-02*V(F1141) -1.4883869880776945e-02*V(F1142) +1.3105908237499731e-02*V(F1143) -9.4387201874225387e-03*V(F1144) +3.8746341783690483e-03*V(F1145) -1.9174208547108830e-03*V(F1146) +1.5557397178551200e-03*V(F1147) -3.9397872604870912e-03*V(F1148) +1.0108249650133584e-02*V(F1149) -1.7242346714005770e-02*V(F1150) +2.2196482777286832e-02*V(F1151) -1.9835138797183113e-02*V(F1152) +1.4123535683617339e-02*V(F1153) -5.9470857100106462e-03*V(F1154) +2.6089078611290823e-03*V(F1155) -1.9367677927516441e-03*V(F1156) +4.8531839037690566e-03*V(F1157) -1.2475508738189743e-02*V(F1158) +2.1285413102250253e-02*V(F1159) -2.7404915772926575e-02*V(F1160) +2.4457185036105136e-02*V(F1161) -1.7432358276693698e-02*V(F1162) +7.3237891210048787e-03*V(F1163) -3.2489796989893442e-03*V(F1164) +1.7508346669994081e-03*V(F1165) -4.2787459229093857e-03*V(F1166) +1.1049467580247895e-02*V(F1167) -1.8863101486143560e-02*V(F1168) +2.4294049093243019e-02*V(F1169) -2.1612346859984286e-02*V(F1170) +1.5442306066631269e-02*V(F1171) -6.4525304869047680e-03*V(F1172) +2.9393978040712829e-03*V(F1173) -1.0866836010305619e-03*V(F1174) +2.5300864571644408e-03*V(F1175) -6.5937546595696362e-03*V(F1176) +1.1269245558827683e-02*V(F1177) -1.4523087772987752e-02*V(F1178) +1.2839021189477691e-02*V(F1179) -9.2182374806561544e-03*V(F1180) +3.8102662271367275e-03*V(F1181) -1.8270759280461092e-03*V(F1182) +4.3234469706658477e-04*V(F1183) -8.9100511503150054e-04*V(F1184) +2.3800946269827215e-03*V(F1185) -4.0799434022111749e-03*V(F1186) +5.2668379834714500e-03*V(F1187) -4.5787544543027161e-03*V(F1188) +3.3303652294128234e-03*V(F1189) -1.3368026069245761e-03*V(F1190) +7.2939268987790679e-04*V(F1191) -8.7913248543702339e-05*V(F1192) +9.1217371108186191e-05*V(F1193) -2.9466365067782262e-04*V(F1194) +5.1555244465976828e-04*V(F1195) -6.7311326043846857e-04*V(F1196) +5.1913996808808426e-04*V(F1197) -4.1482517559452645e-04*V(F1198) +1.3242936452789850e-04*V(F1199) -1.5024321163243593e-04*V(F1200) +2.4461740597668707e-05*V(F1201) -6.3619145474711110e-05*V(F1202) +1.6245537981279885e-04*V(F1203) -2.7694707012897803e-04*V(F1204) +3.5640058388355320e-04*V(F1205) -3.1953312875925650e-04*V(F1206) +2.2694770948141494e-04*V(F1207) -9.6099672714308835e-05*V(F1208) +4.0985446700122511e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1134)));
	I(F1135)<+( -1.5173880019340518e-12*V(reduced_0) +6.2371966262271182e-11*V(reduced_1) +1.0900943000565828e-04*V(F1129) -1.7225618257608612e-03*V(F1130) +4.2113458293595411e-03*V(F1131) -7.7874183130993199e-03*V(F1132) +1.0622334138989430e-02*V(F1133) -1.0807802604637434e-02*V(F1134) +9.3351664268605632e-03*V(F1135) -4.4514068866147241e-03*V(F1136) +2.0632419466633137e-04*V(F1137) +4.9143500088166337e-04*V(F1138) -1.2618433303834900e-03*V(F1139) +3.6080016415559811e-03*V(F1140) -6.7500531793074211e-03*V(F1141) +9.1817270866172470e-03*V(F1142) -9.4387201874357295e-03*V(F1143) +6.2178695576996538e-03*V(F1144) -3.3071380034315509e-03*V(F1145) +1.5265561854510197e-03*V(F1146) -6.7404527484643724e-04*V(F1147) +1.9256702956070833e-03*V(F1148) -5.4096085231384820e-03*V(F1149) +1.0108249650170570e-02*V(F1150) -1.3753688703498582e-02*V(F1151) +1.4123535683635637e-02*V(F1152) -9.6034097869881485e-03*V(F1153) +5.0384052384437354e-03*V(F1154) -2.0759261374441612e-03*V(F1155) +8.3875958063806650e-04*V(F1156) -2.3726485535017160e-03*V(F1157) +6.6757573013791335e-03*V(F1158) -1.2475508738235679e-02*V(F1159) +1.6974233698101658e-02*V(F1160) -1.7432358276716790e-02*V(F1161) +1.1820062175145566e-02*V(F1162) -6.2088272101224794e-03*V(F1163) +2.5853770183676696e-03*V(F1164) -7.5745524303363584e-04*V(F1165) +2.0929481965577877e-03*V(F1166) -5.9111151681216639e-03*V(F1167) +1.1049467580289164e-02*V(F1168) -1.5033015799732695e-02*V(F1169) +1.5442306066652365e-02*V(F1170) -1.0400157501494875e-02*V(F1171) +5.4788750970963486e-03*V(F1172) -2.3393245184692053e-03*V(F1173) +4.6922186475529539e-04*V(F1174) -1.2389368147732406e-03*V(F1175) +3.5256136444536293e-03*V(F1176) -6.5937546595949432e-03*V(F1177) +8.9698215300103509e-03*V(F1178) -9.2182374806694511e-03*V(F1179) +6.1250343142420739e-03*V(F1180) -3.2456072345135598e-03*V(F1181) +1.4544252637789549e-03*V(F1182) -1.8585023395986230e-04*V(F1183) +4.3760864886863452e-04*V(F1184) -1.2708543266729780e-03*V(F1185) +2.3800946269925071e-03*V(F1186) -3.2367015538269845e-03*V(F1187) +3.3303652294183043e-03*V(F1188) -2.1331166577373407e-03*V(F1189) +1.1486540959659564e-03*V(F1190) -5.8094177966542529e-04*V(F1191) +3.7142722947204723e-05*V(F1192) -4.5943240185863837e-05*V(F1193) +1.5582810368405849e-04*V(F1194) -2.9466365067958109e-04*V(F1195) +3.9980286225621889e-04*V(F1196) -4.1482517559583915e-04*V(F1197) +1.9736926770672289e-04*V(F1198) -1.2257757157998231e-04*V(F1199) +1.1990985997371582e-04*V(F1200) -1.0610425158740753e-05*V(F1201) +3.1078179641249456e-05*V(F1202) -8.6964610646377596e-05*V(F1203) +1.6245537981336694e-04*V(F1204) -2.2105763917919637e-04*V(F1205) +2.2694770948155339e-04*V(F1206) -1.5539227965507077e-04*V(F1207) +8.1284118988355765e-05*V(F1208) -3.2607821878354952e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1135)));
	I(F1136)<+( +9.6275652535002681e-12*V(reduced_0) -3.9573937214064675e-10*V(reduced_1) -4.4966273201376265e-05*V(F1129) +5.8849704229418595e-04*V(F1130) -1.7225618257642346e-03*V(F1131) +3.5894236219841933e-03*V(F1132) -5.2742547628101509e-03*V(F1133) +5.5416390854454963e-03*V(F1134) -4.4514068866147241e-03*V(F1135) +3.8117561396502258e-03*V(F1136) -2.2978930368570692e-04*V(F1137) -1.2958125821391179e-04*V(F1138) +4.0008096577463879e-04*V(F1139) -1.2618433303924329e-03*V(F1140) +2.5750783557071345e-03*V(F1141) -3.7156728698664477e-03*V(F1142) +3.8746341783909960e-03*V(F1143) -3.3071380034514000e-03*V(F1144) +1.0854510126310146e-03*V(F1145) -1.2203744982460353e-03*V(F1146) +1.7992396063290533e-04*V(F1147) -6.1627578959986271e-04*V(F1148) +1.9256702956195919e-03*V(F1149) -3.9397872605262457e-03*V(F1150) +5.6976902291765129e-03*V(F1151) -5.9470857100411270e-03*V(F1152) +5.0384052384713001e-03*V(F1153) -1.9713287999896531e-03*V(F1154) +1.6683199287348791e-03*V(F1155) -2.2362611953747014e-04*V(F1156) +7.5870076613223974e-04*V(F1157) -2.3726485535172834e-03*V(F1158) +4.8531839038177546e-03*V(F1159) -7.0172455515872308e-03*V(F1160) +7.3237891210433375e-03*V(F1161) -6.2088272101572537e-03*V(F1162) +2.3946602765327028e-03*V(F1163) -2.0766710151065393e-03*V(F1164) +2.0139015164922448e-04*V(F1165) -6.6793683674900976e-04*V(F1166) +2.0929481965718017e-03*V(F1167) -4.2787459229532126e-03*V(F1168) +6.1836997393308361e-03*V(F1169) -6.4525304869399048e-03*V(F1170) +5.4788750971281209e-03*V(F1171) -2.0394903559844239e-03*V(F1172) +1.8767806733282801e-03*V(F1173) -1.2410789960764774e-04*V(F1174) +3.9381986815489271e-04*V(F1175) -1.2389368147818678e-03*V(F1176) +2.5300864571913863e-03*V(F1177) -3.6529986323518286e-03*V(F1178) +3.8102662271588747e-03*V(F1179) -3.2456072345335872e-03*V(F1180) +1.1208679121215465e-03*V(F1181) -1.1642450107333562e-03*V(F1182) +4.8559637520411367e-05*V(F1183) -1.3758649432954332e-04*V(F1184) +4.3760864887199571e-04*V(F1185) -8.9100511504197524e-04*V(F1186) +1.2830574248054491e-03*V(F1187) -1.3368026069336982e-03*V(F1188) +1.1486540959742054e-03*V(F1189) -3.1248944503003528e-04*V(F1190) +4.6264243737829280e-04*V(F1191) -9.2379613054440808e-06*V(F1192) +1.3116174362842718e-05*V(F1193) -4.5943240186475320e-05*V(F1194) +9.1217371110082353e-05*V(F1195) -1.2836784278526738e-04*V(F1196) +1.3242936453006224e-04*V(F1197) -1.2257757158194100e-04*V(F1198) -4.0306966876267374e-05*V(F1199) -9.3637770329998938e-05*V(F1200) +2.8408644185909775e-06*V(F1201) -9.9661963914585249e-06*V(F1202) +3.1078179641419974e-05*V(F1203) -6.3619145475260041e-05*V(F1204) +9.2050681536311193e-05*V(F1205) -9.6099672714523466e-05*V(F1206) +8.1284118988551572e-05*V(F1207) -3.2926095640942868e-05*V(F1208) +2.6240007055826307e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1136)));
	I(F1137)<+( +1.6171301011786896e-12*V(reduced_0) -6.6471847664447255e-11*V(reduced_1) +2.8204506864677451e-06*V(F1129) -4.4966273201859996e-05*V(F1130) +1.0900943000806203e-04*V(F1131) -2.0034567745551570e-04*V(F1132) +2.7150868035494800e-04*V(F1133) -2.6991596145107058e-04*V(F1134) +2.0632419466633137e-04*V(F1135) -2.2978930368570692e-04*V(F1136) +2.1218123070082184e-01*V(F1137) +2.3451838612674908e-05*V(F1138) -1.2958125821464506e-04*V(F1139) +4.9143500088564044e-04*V(F1140) -1.1394259373459564e-03*V(F1141) +1.7691165199493649e-03*V(F1142) -1.9174208547263979e-03*V(F1143) +1.5265561854635001e-03*V(F1144) -1.2203744982555562e-03*V(F1145) +3.6169917353643127e-01*V(F1146) -3.1844387903210355e-05*V(F1147) +1.7992396063396801e-04*V(F1148) -6.7404527485215781e-04*V(F1149) +1.5557397178699553e-03*V(F1150) -2.4101562189070423e-03*V(F1151) +2.6089078611506219e-03*V(F1152) -2.0759261374614884e-03*V(F1153) +1.6683199287480974e-03*V(F1154) -5.1402341883411473e-01*V(F1155) +3.9665046068164834e-05*V(F1156) -2.2362611953879186e-04*V(F1157) +8.3875958064518179e-04*V(F1158) -1.9367677927700953e-03*V(F1159) +3.0010957473469522e-03*V(F1160) -3.2489796990165134e-03*V(F1161) +2.5853770183895250e-03*V(F1162) -2.0766710151232126e-03*V(F1163) +6.3746481422220946e-01*V(F1164) -3.5902216976584699e-05*V(F1165) +2.0139015165040843e-04*V(F1166) -7.5745524304001496e-04*V(F1167) +1.7508346670159569e-03*V(F1168) -2.7143538346700649e-03*V(F1169) +2.9393978040961077e-03*V(F1170) -2.3393245184891755e-03*V(F1171) +1.8767806733435159e-03*V(F1172) -5.7110275052721715e-01*V(F1173) +2.2335460065240067e-05*V(F1174) -1.2410789960836825e-04*V(F1175) +4.6922186475918681e-04*V(F1176) -1.0866836010406610e-03*V(F1177) +1.6862909582972326e-03*V(F1178) -1.8270759280617573e-03*V(F1179) +1.4544252637915434e-03*V(F1180) -1.1642450107429605e-03*V(F1181) +3.4848782998134903e-01*V(F1182) -8.9343477605701012e-06*V(F1183) +4.8559637520683326e-05*V(F1184) -1.8585023396134023e-04*V(F1185) +4.3234469707042762e-04*V(F1186) -6.7236059937732522e-04*V(F1187) +7.2939268988435704e-04*V(F1188) -5.8094177967061384e-04*V(F1189) +4.6264243738225089e-04*V(F1190) -1.3314691679391025e-01*V(F1191) +1.8540892493936158e-06*V(F1192) -9.2379613054833103e-06*V(F1193) +3.7142722947429892e-05*V(F1194) -8.7913248544296672e-05*V(F1195) +1.3785270902777068e-04*V(F1196) -1.5024321163398122e-04*V(F1197) +1.1990985997495849e-04*V(F1198) -9.3637770330945284e-05*V(F1199) +2.2793247463901066e-02*V(F1200) -5.0001210058891356e-07*V(F1201) +2.8408644186011965e-06*V(F1202) -1.0610425158801177e-05*V(F1203) +2.4461740597829951e-05*V(F1204) -3.7875113417011242e-05*V(F1205) +4.0985446700286795e-05*V(F1206) -3.2607821878486859e-05*V(F1207) +2.6240007055925539e-05*V(F1208) -8.1618219918018868e-03*V(F1209) -4.0647969644206755e-01*V(F1210) +4.8655123222292201e-01*V(F1211) -6.1403691507081248e-01*V(F1212) +5.7261308641928843e-01*V(F1213) -3.7568152511370734e-01*V(F1214) +1.6813624312845038e-01*V(F1215) -4.8716018199945713e-02*V(F1216) +7.3803523872815659e-03*V(F1217) -7.0470066547846300e-01*V(F1218) +8.4466575182105863e-01*V(F1219) -1.0658251081092591e+00*V(F1220) +9.9359234052956968e-01*V(F1221) -6.5150779996475328e-01*V(F1222) +2.9125925824017712e-01*V(F1223) -8.4166396708614963e-02*V(F1224) +1.2817649434111627e-02*V(F1225) +1.0002034477787176e+00*V(F1226) -1.1987357427150469e+00*V(F1227) +1.5126187020129711e+00*V(F1228) -1.4101417980442588e+00*V(F1229) +9.2468337548105572e-01*V(F1230) -4.1341855489352702e-01*V(F1231) +1.1949153117740062e-01*V(F1232) -1.8190037986127047e-02*V(F1233) -1.2405482245779755e+00*V(F1234) +1.4868015714668872e+00*V(F1235) -1.8761111112212940e+00*V(F1236) +1.7490041311669500e+00*V(F1237) -1.1468835380132236e+00*V(F1238) +5.1275837743824637e-01*V(F1239) -1.4820116389424348e-01*V(F1240) +2.2561315652445468e-02*V(F1241) +1.1117172853715487e+00*V(F1242) -1.3324279959915946e+00*V(F1243) +1.6813115342005776e+00*V(F1244) -1.5673934160158449e+00*V(F1245) +1.0277850648548994e+00*V(F1246) -4.5950216694599766e-01*V(F1247) +1.3280266944636021e-01*V(F1248) -2.0218928185382377e-02*V(F1249) -6.7873832733695250e-01*V(F1250) +8.1352507513170924e-01*V(F1251) -1.0265338667445152e+00*V(F1252) +9.5697020408635447e-01*V(F1253) -6.2750135955239505e-01*V(F1254) +2.8053321166638873e-01*V(F1255) -8.1071093007338280e-02*V(F1256) +1.2344997404197384e-02*V(F1257) +2.5966917120994160e-01*V(F1258) -3.1126900106044209e-01*V(F1259) +3.9276525501531961e-01*V(F1260) -3.6613961523111749e-01*V(F1261) +2.4007300962255801e-01*V(F1262) -1.0731851881444586e-01*V(F1263) +3.1007351449810715e-02*V(F1264) -4.7235641706966274e-03*V(F1265) -4.4730592033621099e-02*V(F1266) +5.3646381174466726e-02*V(F1267) -6.7688275663237471e-02*V(F1268) +6.3091844917619599e-02*V(F1269) -4.1359721805436851e-02*V(F1270) +1.8481154366253388e-02*V(F1271) -5.3344260216011494e-03*V(F1272) +8.1421589694148731e-04*V(F1273) +1.5876720008591878e-02*V(F1274) -1.9027648215552133e-02*V(F1275) +2.4010008155280808e-02*V(F1276) -2.2383513851686826e-02*V(F1277) +1.4677870163775935e-02*V(F1278) -6.5624914643073124e-03*V(F1279) +1.8968674458650016e-03*V(F1280) -2.8873010746557079e-04*V(F1281))+ ddt(( +1.0000000000000000e-03*V(Vol_F1137)));
	I(F1138)<+( +9.6275652535364282e-12*V(reduced_0) -3.9573937214213733e-10*V(reduced_1) +3.6169917352708225e-01*V(F1129) -1.2203744982443754e-03*V(F1130) +1.5265561854483098e-03*V(F1131) -1.9174208547075356e-03*V(F1132) +1.7691165199324429e-03*V(F1133) -1.1394259373356216e-03*V(F1134) +4.9143500088166337e-04*V(F1135) -1.2958125821391179e-04*V(F1136) +2.3451838612674908e-05*V(F1137) +2.4166824846069228e+00*V(F1138) -5.2189317661358002e-03*V(F1139) +6.0408610147971954e-03*V(F1140) -7.6522665328723942e-03*V(F1141) +7.1954222896242854e-03*V(F1142) -4.7874144681973796e-03*V(F1143) +2.2006255402814241e-03*V(F1144) -6.7774650574936568e-04*V(F1145) +9.0704632432471929e-05*V(F1146) -1.9262169659084225e+00*V(F1147) +3.3840325351479025e-03*V(F1148) -3.7156944677108387e-03*V(F1149) +4.7357248186084425e-03*V(F1150) -4.5127467930029339e-03*V(F1151) +3.0689899442346664e-03*V(F1152) -1.4678004621546344e-03*V(F1153) +4.9049671310231015e-04*V(F1154) -5.4855328089546798e-05*V(F1155) +2.5045109672871830e+00*V(F1156) -4.5351222574851295e-03*V(F1157) +5.0227013262682139e-03*V(F1158) -6.3950148294052329e-03*V(F1159) +6.0805061094843680e-03*V(F1160) -4.1204627856909056e-03*V(F1161) +1.9583236159011518e-03*V(F1162) -6.4641266712095555e-04*V(F1163) +7.4362250039494457e-05*V(F1164) -2.3713716671988134e+00*V(F1165) +4.2791018033377258e-03*V(F1166) -4.7345340116689907e-03*V(F1167) +6.0288064680966069e-03*V(F1168) -5.7337344107959267e-03*V(F1169) +3.8870419016916093e-03*V(F1170) -1.8487093869461596e-03*V(F1171) +6.1109264234458511e-04*V(F1172) -7.0073393905987138e-05*V(F1173) +1.5934850043584756e+00*V(F1174) -2.8505558381285976e-03*V(F1175) +3.1462246136758141e-03*V(F1176) -4.0074615865684287e-03*V(F1177) +3.8137066223263849e-03*V(F1178) -2.5880304771166334e-03*V(F1179) +1.2330997736429384e-03*V(F1180) -4.0904153191148005e-04*V(F1181) +4.6528067440485677e-05*V(F1182) -7.5326141327351193e-01*V(F1183) +1.3333374003392754e-03*V(F1184) -1.4672003656117662e-03*V(F1185) +1.8694938503481479e-03*V(F1186) -1.7804795124050775e-03*V(F1187) +1.2097656312292078e-03*V(F1188) -5.7767882415823610e-04*V(F1189) +1.9245221493156947e-04*V(F1190) -2.1676111368726172e-05*V(F1191) +2.7097058719125433e-01*V(F1192) -4.9674453088410276e-04*V(F1193) +5.5203073152773434e-04*V(F1194) -7.0257597380531003e-04*V(F1195) +6.6744273931440752e-04*V(F1196) -4.5165492052278100e-04*V(F1197) +2.1411872627689218e-04*V(F1198) -7.0326630330303771e-05*V(F1199) +8.1820851128467689e-06*V(F1200) +2.2793247463417241e-02*V(F1201) -9.3637770329695741e-05*V(F1202) +1.1990985997322121e-04*V(F1203) -1.5024321163181111e-04*V(F1204) +1.3785270902581516e-04*V(F1205) -8.7913248543090985e-05*V(F1206) +3.7142722946955425e-05*V(F1207) -9.2379613053796131e-06*V(F1208) +1.8540892493859749e-06*V(F1209) +1.2817649434079238e-02*V(F1289) +8.4503425924156134e-02*V(F1297) -6.7052864882365407e-02*V(F1305) +8.7236017742371788e-02*V(F1313) -8.2592781395580836e-02*V(F1321) +5.5490041480098631e-02*V(F1329) -2.6225389339989538e-02*V(F1337) +9.4406820865622302e-03*V(F1345) +8.1421589694872381e-04*V(F1353) -8.4166396707456875e-02*V(F1354) +2.9125925823413346e-01*V(F1355) -6.5150779994886232e-01*V(F1356) +9.9359234050344292e-01*V(F1357) -1.0658251080799959e+00*V(F1358) +8.4466575179746306e-01*V(F1359) -7.0470066545978371e-01*V(F1360) -5.5700564246465700e-01*V(F1361) +1.9237948239482601e+00*V(F1362) -4.2997862142122809e+00*V(F1363) +6.5547312367563038e+00*V(F1364) -7.0295422310453599e+00*V(F1365) +5.5703004217403329e+00*V(F1366) -4.6518939308783391e+00*V(F1367) +4.4254745871377649e-01*V(F1368) -1.5274813052305465e+00*V(F1369) +3.4130723983670026e+00*V(F1370) -5.2022669613632759e+00*V(F1371) +5.5786508662864529e+00*V(F1372) -4.4204326215327816e+00*V(F1373) +3.6928479851679481e+00*V(F1374) -5.7565653920470805e-01*V(F1375) +1.9870900058532082e+00*V(F1376) -4.4402054812718079e+00*V(F1377) +6.7679694598216429e+00*V(F1378) -7.2577119262350971e+00*V(F1379) +5.7509218786209724e+00*V(F1380) -4.8041279222912383e+00*V(F1381) +5.4502753186537278e-01*V(F1382) -1.8813435066491520e+00*V(F1383) +4.2038941221183270e+00*V(F1384) -6.4077585084256228e+00*V(F1385) +6.8714266225958802e+00*V(F1386) -5.4448310002218987e+00*V(F1387) +4.5484537333254078e+00*V(F1388) -3.6619554295394718e-01*V(F1389) +1.2640135007744953e+00*V(F1390) -2.8244297484680638e+00*V(F1391) +4.3050953675610861e+00*V(F1392) -4.6165991727646913e+00*V(F1393) +3.6581291935672842e+00*V(F1394) -3.0559347099214840e+00*V(F1395) +1.7307966461831470e-01*V(F1396) -5.9740857096289046e-01*V(F1397) +1.3348884109850021e+00*V(F1398) -2.0346705990327063e+00*V(F1399) +2.1818848876763379e+00*V(F1400) -1.7288923609654783e+00*V(F1401) +1.4443079512844330e+00*V(F1402) -6.2293090288803442e-02*V(F1403) +2.1503530714340172e-01*V(F1404) -4.8050943509123356e-01*V(F1405) +7.3242075300088771e-01*V(F1406) -7.8542363456242426e-01*V(F1407) +6.2236132984989834e-01*V(F1408) -5.1989012975483984e-01*V(F1409) -5.3344260215624356e-03*V(F1410) +1.8481154365981918e-02*V(F1411) -4.1359721804681074e-02*V(F1412) +6.3091844916349116e-02*V(F1413) -6.7688275661797012e-02*V(F1414) +5.3646381173297925e-02*V(F1415) -4.4730592032695082e-02*V(F1416))+ ddt(( +1.0000000000000000e-03*V(Vol_F1138)));
	I(F1139)<+( +5.7317597788369316e-11*V(reduced_0) -2.3560297504223970e-09*V(reduced_1) -1.2203744982370892e-03*V(F1129) +1.0854510125987314e-03*V(F1130) -3.3071380034038608e-03*V(F1131) +3.8746341783341613e-03*V(F1132) -3.7156728698173411e-03*V(F1133) +2.5750783556791916e-03*V(F1134) -1.2618433303834900e-03*V(F1135) +4.0008096577463879e-04*V(F1136) -1.2958125821464506e-04*V(F1137) -5.2189317661358002e-03*V(F1138) +2.6319647771954356e-02*V(F1139) -3.7150668206667299e-02*V(F1140) +4.5486949516690509e-02*V(F1141) -4.3380230332826016e-02*V(F1142) +2.9668448969655096e-02*V(F1143) -1.4319841749564577e-02*V(F1144) +4.7946944691822499e-03*V(F1145) -6.7774650575430618e-04*V(F1146) +3.3840325351372578e-03*V(F1147) -2.6017588927652508e-02*V(F1148) +3.3589779435259350e-02*V(F1149) -4.1435353178565039e-02*V(F1150) +3.9480096190104154e-02*V(F1151) -2.6941273420056113e-02*V(F1152) +1.2970072450588748e-02*V(F1153) -4.3823457796236497e-03*V(F1154) +4.9049671310635249e-04*V(F1155) -4.5351222574725658e-03*V(F1156) +3.2950799039231905e-02*V(F1157) -4.2981097578545513e-02*V(F1158) +5.2972857305738072e-02*V(F1159) -5.0478682557285597e-02*V(F1160) +3.4455848816433939e-02*V(F1161) -1.6592857241689636e-02*V(F1162) +5.6003479990028721e-03*V(F1163) -6.4641266712623985e-04*V(F1164) +4.2791018033262089e-03*V(F1165) -3.1296162853001984e-02*V(F1166) +4.0772832407633602e-02*V(F1167) -5.0256556780280244e-02*V(F1168) +4.7889656400097944e-02*V(F1169) -3.2687600203047819e-02*V(F1170) +1.5740749201378731e-02*V(F1171) -5.3134299891932453e-03*V(F1172) +6.1109264234960106e-04*V(F1173) -2.8505558381211010e-03*V(F1174) +2.1191526906237466e-02*V(F1175) -2.7525547024555327e-02*V(F1176) +3.3936799877881917e-02*V(F1177) -3.2337470431812620e-02*V(F1178) +2.2070584474638565e-02*V(F1179) -1.0627158570438248e-02*V(F1180) +3.5884247338547636e-03*V(F1181) -4.0904153191484866e-04*V(F1182) +1.3333374003356932e-03*V(F1183) -1.0109493354956381e-02*V(F1184) +1.3084309435993256e-02*V(F1185) -1.6136915961959687e-02*V(F1186) +1.5375852633592360e-02*V(F1187) -1.0493177901362040e-02*V(F1188) +5.0520056368596068e-03*V(F1189) -1.7065300159812193e-03*V(F1190) +1.9245221493314278e-04*V(F1191) -4.9674453088196006e-04*V(F1192) +3.5255730564628207e-03*V(F1193) -4.6190892641940814e-03*V(F1194) +5.6907196388081864e-03*V(F1195) -5.4230299478133124e-03*V(F1196) +3.7020807937513467e-03*V(F1197) -1.7830400204953657e-03*V(F1198) +6.0152643981981730e-04*V(F1199) -7.0326630330805635e-05*V(F1200) -9.3637770330889827e-05*V(F1201) -4.0306966878612578e-05*V(F1202) -1.2257757157796453e-04*V(F1203) +1.3242936452528717e-04*V(F1204) -1.2836784278113915e-04*V(F1205) +9.1217371107727371e-05*V(F1206) -4.5943240185700204e-05*V(F1207) +1.3116174362767385e-05*V(F1208) -9.2379613054693596e-06*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1139)));
	I(F1140)<+( -9.0337518255118360e-12*V(reduced_0) +3.7133077588882003e-10*V(reduced_1) +1.5265561854387454e-03*V(F1129) -3.3071380033887357e-03*V(F1130) +6.2178695576308148e-03*V(F1131) -9.4387201873566608e-03*V(F1132) +9.1817270865563200e-03*V(F1133) -6.7500531792811184e-03*V(F1134) +3.6080016415559811e-03*V(F1135) -1.2618433303924329e-03*V(F1136) +4.9143500088564044e-04*V(F1137) +6.0408610147971954e-03*V(F1138) -3.7150668206667299e-02*V(F1139) +7.5652771929976062e-02*V(F1140) -9.4631794265466251e-02*V(F1141) +9.2709021762595684e-02*V(F1142) -6.8025628147795517e-02*V(F1143) +3.6654286128208230e-02*V(F1144) -1.4319841749611355e-02*V(F1145) +2.2006255403070759e-03*V(F1146) -3.7156944676966209e-03*V(F1147) +3.3589779435240615e-02*V(F1148) -6.9313932751524240e-02*V(F1149) +8.3769573040761464e-02*V(F1150) -8.2182665248309097e-02*V(F1151) +6.0279049525299291e-02*V(F1152) -3.2531640025075068e-02*V(F1153) +1.2970072450623565e-02*V(F1154) -1.4678004621753303e-03*V(F1155) +5.0227013262514972e-03*V(F1156) -4.2981097578522476e-02*V(F1157) +8.8553194943069416e-02*V(F1158) -1.0746573424411791e-01*V(F1159) +1.0541187033677255e-01*V(F1160) -7.7320698764308818e-02*V(F1161) +4.1720684862659486e-02*V(F1162) -1.6592857241735558e-02*V(F1163) +1.9583236159282313e-03*V(F1164) -4.7345340116536792e-03*V(F1165) +4.0772832407612349e-02*V(F1166) -8.4019281229295403e-02*V(F1167) +1.0191350413679484e-01*V(F1168) -9.9967776637879785e-02*V(F1169) +7.3326999193190856e-02*V(F1170) -3.9566668435407445e-02*V(F1171) +1.5740749201422183e-02*V(F1172) -1.8487093869718522e-03*V(F1173) +3.1462246136658377e-03*V(F1174) -2.7525547024541616e-02*V(F1175) +5.6747168304112361e-02*V(F1176) -6.8749982130322351e-02*V(F1177) +6.7440773910921431e-02*V(F1178) -4.9467570475040870e-02*V(F1179) +2.6693810536699947e-02*V(F1180) -1.0627158570467339e-02*V(F1181) +1.2330997736601831e-03*V(F1182) -1.4672003656069725e-03*V(F1183) +1.3084309435987101e-02*V(F1184) -2.6989671281089905e-02*V(F1185) +3.2651302407810986e-02*V(F1186) -3.2031430201952107e-02*V(F1187) +2.3494563860698196e-02*V(F1188) -1.2679045030153022e-02*V(F1189) +5.0520056368732174e-03*V(F1190) -5.7767882416629628e-04*V(F1191) +5.5203073152479767e-04*V(F1192) -4.6190892641913674e-03*V(F1193) +9.5102257376639323e-03*V(F1194) -1.1561690739814563e-02*V(F1195) +1.1339902817543204e-02*V(F1196) -8.3180991006851102e-03*V(F1197) +4.4879105876178688e-03*V(F1198) -1.7830400205000843e-03*V(F1199) +2.1411872627950665e-04*V(F1200) +1.1990985997487436e-04*V(F1201) -1.2257757157923987e-04*V(F1202) +1.9736926770335552e-04*V(F1203) -4.1482517559211703e-04*V(F1204) +3.9980286225375949e-04*V(F1205) -2.9466365067902999e-04*V(F1206) +1.5582810368466339e-04*V(F1207) -4.5943240186476641e-05*V(F1208) +3.7142722947406392e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1140)));
	I(F1141)<+( +1.0217484823140643e-10*V(reduced_0) -4.1998791203167543e-09*V(reduced_1) -1.9174208546956408e-03*V(F1129) +3.8746341783174056e-03*V(F1130) -9.4387201873460565e-03*V(F1131) +1.3105908237420819e-02*V(F1132) -1.4883869880730852e-02*V(F1133) +1.1544565643874362e-02*V(F1134) -6.7500531793074211e-03*V(F1135) +2.5750783557071345e-03*V(F1136) -1.1394259373459564e-03*V(F1137) -7.6522665328723942e-03*V(F1138) +4.5486949516690509e-02*V(F1139) -9.4631794265466251e-02*V(F1140) +1.4137100565396860e-01*V(F1141) -1.4589578849850698e-01*V(F1142) +1.1431062728684656e-01*V(F1143) -6.8025628147950615e-02*V(F1144) +2.9668448969806308e-02*V(F1145) -4.7874144682632886e-03*V(F1146) +4.7357248185906789e-03*V(F1147) -4.1435353178543653e-02*V(F1148) +8.3769573040749709e-02*V(F1149) -1.2690035181612747e-01*V(F1150) +1.2856298971433833e-01*V(F1151) -1.0093697659591772e-01*V(F1152) +6.0279049525418543e-02*V(F1153) -2.6941273420169824e-02*V(F1154) +3.0689899442875976e-03*V(F1155) -6.3950148293843625e-03*V(F1156) +5.2972857305711961e-02*V(F1157) -1.0746573424410302e-01*V(F1158) +1.6252155409770958e-01*V(F1159) -1.6502196175015821e-01*V(F1160) +1.2952895629254271e-01*V(F1161) -7.7320698764464901e-02*V(F1162) +3.4455848816583534e-02*V(F1163) -4.1204627857601818e-03*V(F1164) +6.0288064680775024e-03*V(F1165) -5.0256556780256187e-02*V(F1166) +1.0191350413678102e-01*V(F1167) -1.5415571834753464e-01*V(F1168) +1.5648578162706042e-01*V(F1169) -1.2283238896125376e-01*V(F1170) +7.3326999193338557e-02*V(F1171) -3.2687600203189421e-02*V(F1172) +3.8870419017573250e-03*V(F1173) -4.0074615865559778e-03*V(F1174) +3.3936799877866387e-02*V(F1175) -6.8749982130313497e-02*V(F1176) +1.0404342861310997e-01*V(F1177) -1.0554685481223243e-01*V(F1178) +8.2854306795104360e-02*V(F1179) -4.9467570475139964e-02*V(F1180) +2.2070584474733396e-02*V(F1181) -2.5880304771607413e-03*V(F1182) +1.8694938503421557e-03*V(F1183) -1.6136915961952648e-02*V(F1184) +3.2651302407807205e-02*V(F1185) -4.9442250096156312e-02*V(F1186) +5.0117461524093798e-02*V(F1187) -3.9345658810995943e-02*V(F1188) +2.3494563860744878e-02*V(F1189) -1.0493177901406515e-02*V(F1190) +1.2097656312498298e-03*V(F1191) -7.0257597380161724e-04*V(F1192) +5.6907196388048592e-03*V(F1193) -1.1561690739813396e-02*V(F1194) +1.7472310525413742e-02*V(F1195) -1.7758062754068025e-02*V(F1196) +1.3937166050066488e-02*V(F1197) -8.3180991007018642e-03*V(F1198) +3.7020807937668994e-03*V(F1199) -4.5165492052950869e-04*V(F1200) -1.5024321163389513e-04*V(F1201) +1.3242936452692098e-04*V(F1202) -4.1482517559249623e-04*V(F1203) +5.1913996808588441e-04*V(F1204) -6.7311326043858566e-04*V(F1205) +5.1555244466224438e-04*V(F1206) -2.9466365068086365e-04*V(F1207) +9.1217371110040773e-05*V(F1208) -8.7913248544234940e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1141)));
	I(F1142)<+( -4.4195294490557592e-11*V(reduced_0) +1.8166397871887278e-09*V(reduced_1) +1.7691165199216149e-03*V(F1129) -3.7156728698022863e-03*V(F1130) +9.1817270865482744e-03*V(F1131) -1.4883869880721925e-02*V(F1132) +1.6607710640790228e-02*V(F1133) -1.4883869880776945e-02*V(F1134) +9.1817270866172470e-03*V(F1135) -3.7156728698664477e-03*V(F1136) +1.7691165199493649e-03*V(F1137) +7.1954222896242854e-03*V(F1138) -4.3380230332826016e-02*V(F1139) +9.2709021762595684e-02*V(F1140) -1.4589578849850698e-01*V(F1141) +1.7448510902906089e-01*V(F1142) -1.4589578849878604e-01*V(F1143) +9.2709021762957033e-02*V(F1144) -4.3380230333094134e-02*V(F1145) +7.1954222897321505e-03*V(F1146) -4.5127467929867533e-03*V(F1147) +3.9480096190084815e-02*V(F1148) -8.2182665248299813e-02*V(F1149) +1.2856298971432889e-01*V(F1150) -1.5586215117788757e-01*V(F1151) +1.2856298971455407e-01*V(F1152) -8.2182665248587167e-02*V(F1153) +3.9480096190306291e-02*V(F1154) -4.5127467930895001e-03*V(F1155) +6.0805061094653589e-03*V(F1156) -5.0478682557262067e-02*V(F1157) +1.0541187033676093e-01*V(F1158) -1.6502196175014602e-01*V(F1159) +1.9973097337582646e-01*V(F1160) -1.6502196175043987e-01*V(F1161) +1.0541187033713621e-01*V(F1162) -5.0478682557551335e-02*V(F1163) +6.0805061095976463e-03*V(F1164) -5.7337344107785213e-03*V(F1165) +4.7889656400076225e-02*V(F1166) -9.9967776637869057e-02*V(F1167) +1.5648578162704913e-01*V(F1168) -1.8943653587561265e-01*V(F1169) +1.5648578162732707e-01*V(F1170) -9.9967776638223829e-02*V(F1171) +4.7889656400349430e-02*V(F1172) -5.7337344109033772e-03*V(F1173) +3.8137066223150394e-03*V(F1174) -3.2337470431798583e-02*V(F1175) +6.7440773910914562e-02*V(F1176) -1.0554685481222519e-01*V(F1177) +1.2783330793642017e-01*V(F1178) -1.0554685481241133e-01*V(F1179) +6.7440773911152288e-02*V(F1180) -3.2337470431981076e-02*V(F1181) +3.8137066223985073e-03*V(F1182) -1.7804795123996151e-03*V(F1183) +1.5375852633585969e-02*V(F1184) -3.2031430201949096e-02*V(F1185) +5.0117461524090752e-02*V(F1186) -6.0734913845402569e-02*V(F1187) +5.0117461524178189e-02*V(F1188) -3.2031430202060930e-02*V(F1189) +1.5375852633671401e-02*V(F1190) -1.7804795124388077e-03*V(F1191) +6.6744273931103586e-04*V(F1192) -5.4230299478102550e-03*V(F1193) +1.1339902817542135e-02*V(F1194) -1.7758062754067258e-02*V(F1195) +2.1477993663442774e-02*V(F1196) -1.7758062754098490e-02*V(F1197) +1.1339902817582343e-02*V(F1198) -5.4230299478410550e-03*V(F1199) +6.6744273932544469e-04*V(F1200) +1.3785270902771910e-04*V(F1201) -1.2836784278265754e-04*V(F1202) +3.9980286225417360e-04*V(F1203) -6.7311326043876000e-04*V(F1204) +6.8441402779287591e-04*V(F1205) -6.7311326044165460e-04*V(F1206) +3.9980286225794630e-04*V(F1207) -1.2836784278512682e-04*V(F1208) +1.3785270902766489e-04*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1142)));
	I(F1143)<+( +1.0217484823136590e-10*V(reduced_0) -4.1998791203150776e-09*V(reduced_1) -1.1394259373287874e-03*V(F1129) +2.5750783556695573e-03*V(F1130) -6.7500531792754259e-03*V(F1131) +1.1544565643868123e-02*V(F1132) -1.4883869880767219e-02*V(F1133) +1.3105908237499731e-02*V(F1134) -9.4387201874357295e-03*V(F1135) +3.8746341783909960e-03*V(F1136) -1.9174208547263979e-03*V(F1137) -4.7874144681973796e-03*V(F1138) +2.9668448969655096e-02*V(F1139) -6.8025628147795517e-02*V(F1140) +1.1431062728684656e-01*V(F1141) -1.4589578849878604e-01*V(F1142) +1.4137100565444977e-01*V(F1143) -9.4631794265934280e-02*V(F1144) +4.5486949517001607e-02*V(F1145) -7.6522665329923460e-03*V(F1146) +3.0689899442244545e-03*V(F1147) -2.6941273420043748e-02*V(F1148) +6.0279049525292762e-02*V(F1149) -1.0093697659591100e-01*V(F1150) +1.2856298971454405e-01*V(F1151) -1.2690035181649864e-01*V(F1152) +8.3769573041121703e-02*V(F1153) -4.1435353178799733e-02*V(F1154) +4.7357248187046190e-03*V(F1155) -4.1204627856789126e-03*V(F1156) +3.4455848816418867e-02*V(F1157) -7.7320698764300630e-02*V(F1158) +1.2952895629253416e-01*V(F1159) -1.6502196175042694e-01*V(F1160) +1.6252155409819452e-01*V(F1161) -1.0746573424458884e-01*V(F1162) +5.2972857306046540e-02*V(F1163) -6.3950148295310915e-03*V(F1164) +3.8870419016806307e-03*V(F1165) -3.2687600203033941e-02*V(F1166) +7.3326999193183265e-02*V(F1167) -1.2283238896124576e-01*V(F1168) +1.5648578162731497e-01*V(F1169) -1.5415571834799358e-01*V(F1170) +1.0191350413724043e-01*V(F1171) -5.0256556780572177e-02*V(F1172) +6.0288064682159880e-03*V(F1173) -2.5880304771094763e-03*V(F1174) +2.2070584474629600e-02*V(F1175) -4.9467570475036020e-02*V(F1176) +8.2854306795099295e-02*V(F1177) -1.0554685481240361e-01*V(F1178) +1.0404342861341800e-01*V(F1179) -6.8749982130621334e-02*V(F1180) +3.3936799878077496e-02*V(F1181) -4.0074615866485556e-03*V(F1182) +1.2097656312257613e-03*V(F1183) -1.0493177901357958e-02*V(F1184) +2.3494563860696073e-02*V(F1185) -3.9345658810993799e-02*V(F1186) +5.0117461524175004e-02*V(F1187) -4.9442250096301682e-02*V(F1188) +3.2651302407951950e-02*V(F1189) -1.6136915962051489e-02*V(F1190) +1.8694938503856263e-03*V(F1191) -4.5165492052065504e-04*V(F1192) +3.7020807937493978e-03*V(F1193) -8.3180991006843608e-03*V(F1194) +1.3937166050065918e-02*V(F1195) -1.7758062754097796e-02*V(F1196) +1.7472310525466335e-02*V(F1197) -1.1561690739865342e-02*V(F1198) +5.6907196388404748e-03*V(F1199) -7.0257597381759242e-04*V(F1200) -8.7913248544291332e-05*V(F1201) +9.1217371108694465e-05*V(F1202) -2.9466365067931823e-04*V(F1203) +5.1555244466238651e-04*V(F1204) -6.7311326044174676e-04*V(F1205) +5.1913996809111818e-04*V(F1206) -4.1482517559747716e-04*V(F1207) +1.3242936452984396e-04*V(F1208) -1.5024321163385895e-04*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1143)));
	I(F1144)<+( -9.0337518254648870e-12*V(reduced_0) +3.7133077588688820e-10*V(reduced_1) +4.9143500087880086e-04*V(F1129) -1.2618433303790999e-03*V(F1130) +3.6080016415519054e-03*V(F1131) -6.7500531793007268e-03*V(F1132) +9.1817270866072845e-03*V(F1133) -9.4387201874225387e-03*V(F1134) +6.2178695576996538e-03*V(F1135) -3.3071380034514000e-03*V(F1136) +1.5265561854635001e-03*V(F1137) +2.2006255402814241e-03*V(F1138) -1.4319841749564577e-02*V(F1139) +3.6654286128208230e-02*V(F1140) -6.8025628147950615e-02*V(F1141) +9.2709021762957033e-02*V(F1142) -9.4631794265934280e-02*V(F1143) +7.5652771930382459e-02*V(F1144) -3.7150668206924378e-02*V(F1145) +6.0408610148941543e-03*V(F1146) -1.4678004621503783e-03*V(F1147) +1.2970072450583223e-02*V(F1148) -3.2531640025070627e-02*V(F1149) +6.0279049525411604e-02*V(F1150) -8.2182665248577036e-02*V(F1151) +8.3769573041108256e-02*V(F1152) -6.9313932751834006e-02*V(F1153) +3.3589779435452972e-02*V(F1154) -3.7156944677887061e-03*V(F1155) +1.9583236158961458e-03*V(F1156) -1.6592857241682878e-02*V(F1157) +4.1720684862653831e-02*V(F1158) -7.7320698764455895e-02*V(F1159) +1.0541187033712300e-01*V(F1160) -1.0746573424457138e-01*V(F1161) +8.8553194943474620e-02*V(F1162) -4.2981097578800066e-02*V(F1163) +5.0227013263700847e-03*V(F1164) -1.8487093869415765e-03*V(F1165) +1.5740749201372490e-02*V(F1166) -3.9566668435402193e-02*V(F1167) +7.3326999193330217e-02*V(F1168) -9.9967776638211533e-02*V(F1169) +1.0191350413722416e-01*V(F1170) -8.4019281229678791e-02*V(F1171) +4.0772832407874493e-02*V(F1172) -4.7345340117656114e-03*V(F1173) +1.2330997736399521e-03*V(F1174) -1.0627158570434220e-02*V(F1175) +2.6693810536696571e-02*V(F1176) -4.9467570475134635e-02*V(F1177) +6.7440773911144461e-02*V(F1178) -6.8749982130610968e-02*V(F1179) +5.6747168304369586e-02*V(F1180) -2.7525547024716681e-02*V(F1181) +3.1462246137406698e-03*V(F1182) -5.7767882415680051e-04*V(F1183) +5.0520056368577870e-03*V(F1184) -1.2679045030151598e-02*V(F1185) +2.3494563860742671e-02*V(F1186) -3.2031430202057710e-02*V(F1187) +3.2651302407947697e-02*V(F1188) -2.6989671281211217e-02*V(F1189) +1.3084309436068977e-02*V(F1190) -1.4672003656421083e-03*V(F1191) +2.1411872627601254e-04*V(F1192) -1.7830400204945332e-03*V(F1193) +4.4879105876174481e-03*V(F1194) -8.3180991007013750e-03*V(F1195) +1.1339902817581703e-02*V(F1196) -1.1561690739864497e-02*V(F1197) +9.5102257377079006e-03*V(F1198) -4.6190892642207658e-03*V(F1199) +5.5203073153769339e-04*V(F1200) +3.7142722947450641e-05*V(F1201) -4.5943240186101907e-05*V(F1202) +1.5582810368479016e-04*V(F1203) -2.9466365068093391e-04*V(F1204) +3.9980286225799129e-04*V(F1205) -4.1482517559752969e-04*V(F1206) +1.9736926770800025e-04*V(F1207) -1.2257757158172264e-04*V(F1208) +1.1990985997485689e-04*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1144)));
	I(F1145)<+( +5.7317597788258325e-11*V(reduced_0) -2.3560297504178157e-09*V(reduced_1) -1.2958125821309818e-04*V(F1129) +4.0008096577248659e-04*V(F1130) -1.2618433303869707e-03*V(F1131) +2.5750783556946462e-03*V(F1132) -3.7156728698467690e-03*V(F1133) +3.8746341783690483e-03*V(F1134) -3.3071380034315509e-03*V(F1135) +1.0854510126310146e-03*V(F1136) -1.2203744982555562e-03*V(F1137) -6.7774650574936568e-04*V(F1138) +4.7946944691822499e-03*V(F1139) -1.4319841749611355e-02*V(F1140) +2.9668448969806308e-02*V(F1141) -4.3380230333094134e-02*V(F1142) +4.5486949517001607e-02*V(F1143) -3.7150668206924378e-02*V(F1144) +2.6319647772118461e-02*V(F1145) -5.2189317662074564e-03*V(F1146) +4.9049671310115754e-04*V(F1147) -4.3823457796212254e-03*V(F1148) +1.2970072450618023e-02*V(F1149) -2.6941273420157334e-02*V(F1150) +3.9480096190286633e-02*V(F1151) -4.1435353178777827e-02*V(F1152) +3.3589779435433141e-02*V(F1153) -2.6017588927769668e-02*V(F1154) +3.3840325352056701e-03*V(F1155) -6.4641266711958501e-04*V(F1156) +5.6003479989998103e-03*V(F1157) -1.6592857241728345e-02*V(F1158) +3.4455848816567193e-02*V(F1159) -5.0478682557525620e-02*V(F1160) +5.2972857306017883e-02*V(F1161) -4.2981097578774115e-02*V(F1162) +3.2950799039386608e-02*V(F1163) -4.5351222575606715e-03*V(F1164) +6.1109264234332776e-04*V(F1165) -5.3134299891904064e-03*V(F1166) +1.5740749201415456e-02*V(F1167) -3.2687600203174169e-02*V(F1168) +4.7889656400325442e-02*V(F1169) -5.0256556780545442e-02*V(F1170) +4.0772832407850269e-02*V(F1171) -3.1296162853148242e-02*V(F1172) +4.2791018034093733e-03*V(F1173) -4.0904153191066294e-04*V(F1174) +3.5884247338529465e-03*V(F1175) -1.0627158570463063e-02*V(F1176) +2.2070584474723706e-02*V(F1177) -3.2337470431965831e-02*V(F1178) +3.3936799878060496e-02*V(F1179) -2.7525547024701294e-02*V(F1180) +2.1191526906335287e-02*V(F1181) -2.8505558381766920e-03*V(F1182) +1.9245221493118344e-04*V(F1183) -1.7065300159804363e-03*V(F1184) +5.0520056368714662e-03*V(F1185) -1.0493177901402568e-02*V(F1186) +1.5375852633665201e-02*V(F1187) -1.6136915962044585e-02*V(F1188) +1.3084309436062719e-02*V(F1189) -1.0109493355002381e-02*V(F1190) +1.3333374003617797e-03*V(F1191) -7.0326630330083705e-05*V(F1192) +6.0152643981955742e-04*V(F1193) -1.7830400204997458e-03*V(F1194) +3.7020807937662068e-03*V(F1195) -5.4230299478399864e-03*V(F1196) +5.6907196388392882e-03*V(F1197) -4.6190892642196694e-03*V(F1198) +3.5255730564796783e-03*V(F1199) -4.9674453089149475e-04*V(F1200) -9.2379613054995987e-06*V(F1201) +1.3116174362861395e-05*V(F1202) -4.5943240186491664e-05*V(F1203) +9.1217371110018086e-05*V(F1204) -1.2836784278507336e-04*V(F1205) +1.3242936452978230e-04*V(F1206) -1.2257757158168291e-04*V(F1207) -4.0306966876285859e-05*V(F1208) -9.3637770330887699e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1145)));
	I(F1146)<+( +9.6275652535252273e-12*V(reduced_0) -3.9573937214167282e-10*V(reduced_1) +2.3451838612504325e-05*V(F1129) -1.2958125821365600e-04*V(F1130) +4.9143500088193919e-04*V(F1131) -1.1394259373370594e-03*V(F1132) +1.7691165199352496e-03*V(F1133) -1.9174208547108830e-03*V(F1134) +1.5265561854510197e-03*V(F1135) -1.2203744982460353e-03*V(F1136) +3.6169917353643127e-01*V(F1137) +9.0704632432471929e-05*V(F1138) -6.7774650575430618e-04*V(F1139) +2.2006255403070759e-03*V(F1140) -4.7874144682632886e-03*V(F1141) +7.1954222897321505e-03*V(F1142) -7.6522665329923460e-03*V(F1143) +6.0408610148941543e-03*V(F1144) -5.2189317662074564e-03*V(F1145) +2.4166824846684589e+00*V(F1146) -5.4855328089337595e-05*V(F1147) +4.9049671310531675e-04*V(F1148) -1.4678004621715513e-03*V(F1149) +3.0689899442785302e-03*V(F1150) -4.5127467930751253e-03*V(F1151) +4.7357248186888166e-03*V(F1152) -3.7156944677760062e-03*V(F1153) +3.3840325351960124e-03*V(F1154) -1.9262169659571986e+00*V(F1155) +7.4362250039236756e-05*V(F1156) -6.4641266712490769e-04*V(F1157) +1.9583236159233346e-03*V(F1158) -4.1204627857484282e-03*V(F1159) +6.0805061095790050e-03*V(F1160) -6.3950148295106009e-03*V(F1161) +5.0227013263536091e-03*V(F1162) -4.5351222575481260e-03*V(F1163) +2.5045109673506420e+00*V(F1164) -7.0073393905749102e-05*V(F1165) +6.1109264234836117e-04*V(F1166) -1.8487093869672877e-03*V(F1167) +3.8870419017463689e-03*V(F1168) -5.7337344108860022e-03*V(F1169) +6.0288064681968904e-03*V(F1170) -4.7345340117502539e-03*V(F1171) +4.2791018033976778e-03*V(F1172) -2.3713716672588978e+00*V(F1173) +4.6528067440332384e-05*V(F1174) -4.0904153191405801e-04*V(F1175) +1.2330997736572790e-03*V(F1176) -2.5880304771537686e-03*V(F1177) +3.8137066223874493e-03*V(F1178) -4.0074615866364004e-03*V(F1179) +3.1462246137308968e-03*V(F1180) -2.8505558381692522e-03*V(F1181) +1.5934850043988498e+00*V(F1182) -2.1676111368657661e-05*V(F1183) +1.9245221493281356e-04*V(F1184) -5.7767882416510171e-04*V(F1185) +1.2097656312469644e-03*V(F1186) -1.7804795124342649e-03*V(F1187) +1.8694938503806336e-03*V(F1188) -1.4672003656380950e-03*V(F1189) +1.3333374003587292e-03*V(F1190) -7.5326141329260021e-01*V(F1191) +8.1820851128173294e-06*V(F1192) -7.0326630330726800e-05*V(F1193) +2.1411872627926195e-04*V(F1194) -4.5165492052892968e-04*V(F1195) +6.6744273932452941e-04*V(F1196) -7.0257597381658844e-04*V(F1197) +5.5203073153688924e-04*V(F1198) -4.9674453089089941e-04*V(F1199) +2.7097058719813305e-01*V(F1200) +1.8540892493995493e-06*V(F1201) -9.2379613054843894e-06*V(F1202) +3.7142722947427703e-05*V(F1203) -8.7913248544279880e-05*V(F1204) +1.3785270902773382e-04*V(F1205) -1.5024321163393305e-04*V(F1206) +1.1990985997491411e-04*V(F1207) -9.3637770330918315e-05*V(F1208) +2.2793247464014666e-02*V(F1209) -7.0470066547886834e-01*V(F1210) +8.4466575182165426e-01*V(F1211) -1.0658251081100203e+00*V(F1212) +9.9359234053026824e-01*V(F1213) -6.5150779996519348e-01*V(F1214) +2.9125925824035681e-01*V(F1215) -8.4166396708652919e-02*V(F1216) +1.2817649434112073e-02*V(F1217) -4.6518939310056746e+00*V(F1218) +5.5703004219016590e+00*V(F1219) -7.0295422312455722e+00*V(F1220) +6.5547312369351998e+00*V(F1221) -4.2997862143212302e+00*V(F1222) +1.9237948239898151e+00*V(F1223) -5.5700564247268480e-01*V(F1224) +8.4503425924368492e-02*V(F1225) +3.6928479852706011e+00*V(F1226) -4.4204326216630747e+00*V(F1227) +5.5786508664482142e+00*V(F1228) -5.2022669615078803e+00*V(F1229) +3.4130723984551197e+00*V(F1230) -1.5274813052642078e+00*V(F1231) +4.4254745872032136e-01*V(F1232) -6.7052864882561500e-02*V(F1233) -4.8041279224242492e+00*V(F1234) +5.7509218787897209e+00*V(F1235) -7.2577119264445926e+00*V(F1236) +6.7679694600088949e+00*V(F1237) -4.4402054813858980e+00*V(F1238) +1.9870900058967749e+00*V(F1239) -5.7565653921316351e-01*V(F1240) +8.7236017742616412e-02*V(F1241) +4.5484537334512547e+00*V(F1242) -5.4448310003815559e+00*V(F1243) +6.8714266227940817e+00*V(F1244) -6.4077585086027762e+00*V(F1245) +4.2038941222262620e+00*V(F1246) -1.8813435066903650e+00*V(F1247) +5.4502753187336916e-01*V(F1248) -8.2592781395810499e-02*V(F1249) -3.0559347100060741e+00*V(F1250) +3.6581291936746050e+00*V(F1251) -4.6165991728979234e+00*V(F1252) +4.3050953676801686e+00*V(F1253) -2.8244297485406205e+00*V(F1254) +1.2640135008022013e+00*V(F1255) -3.6619554295932427e-01*V(F1256) +5.5490041480253535e-02*V(F1257) +1.4443079513245620e+00*V(F1258) -1.7288923610164075e+00*V(F1259) +2.1818848877395669e+00*V(F1260) -2.0346705990892264e+00*V(F1261) +1.3348884110194450e+00*V(F1262) -5.9740857097604672e-01*V(F1263) +1.7307966462087229e-01*V(F1264) -2.6225389340065880e-02*V(F1265) -5.1989012976971583e-01*V(F1266) +6.2236132986883552e-01*V(F1267) -7.8542363458594833e-01*V(F1268) +7.3242075302193133e-01*V(F1269) -4.8050943510407246e-01*V(F1270) +2.1503530714832053e-01*V(F1271) -6.2293090289771771e-02*V(F1272) +9.4406820865995146e-03*V(F1273) -4.4730592033480336e-02*V(F1274) +5.3646381174231358e-02*V(F1275) -6.7688275662941166e-02*V(F1276) +6.3091844917355089e-02*V(F1277) -4.1359721805277895e-02*V(F1278) +1.8481154366194734e-02*V(F1279) -5.3344260215911809e-03*V(F1280) +8.1421589694140480e-04*V(F1281))+ ddt(( +1.0000000000000000e-03*V(Vol_F1146)));
	I(F1147)<+( -1.5173880019285511e-12*V(reduced_0) +6.2371966262045633e-11*V(reduced_1) -5.1402341882084823e-01*V(F1129) +1.6683199287320476e-03*V(F1130) -2.0759261374396955e-03*V(F1131) +2.6089078611235697e-03*V(F1132) -2.4101562188827614e-03*V(F1133) +1.5557397178551200e-03*V(F1134) -6.7404527484643724e-04*V(F1135) +1.7992396063290533e-04*V(F1136) -3.1844387903210355e-05*V(F1137) -1.9262169659084225e+00*V(F1138) +3.3840325351372578e-03*V(F1139) -3.7156944676966209e-03*V(F1140) +4.7357248185906789e-03*V(F1141) -4.5127467929867533e-03*V(F1142) +3.0689899442244545e-03*V(F1143) -1.4678004621503783e-03*V(F1144) +4.9049671310115754e-04*V(F1145) -5.4855328089337595e-05*V(F1146) +4.3547863464915402e+00*V(F1147) -8.0505131825657737e-03*V(F1148) +8.9670834713065639e-03*V(F1149) -1.1409439419892035e-02*V(F1150) +1.0832565173087555e-02*V(F1151) -7.3233679283632438e-03*V(F1152) +3.4659468184930903e-03*V(F1153) -1.1345358740249812e-03*V(F1154) +1.3300794296433423e-04*V(F1155) -4.0576961983066928e+00*V(F1156) +6.3434130088026635e-03*V(F1157) -6.7146425906956129e-03*V(F1158) +8.5958069067661666e-03*V(F1159) -8.2689763445733481e-03*V(F1160) +5.7090100368608690e-03*V(F1161) -2.8022831515358347e-03*V(F1162) +9.8294915894263130e-04*V(F1163) -9.7900755495366714e-05*V(F1164) +4.0298073473993741e+00*V(F1165) -6.3608429840930755e-03*V(F1166) +6.7549686937332506e-03*V(F1167) -8.6440003321548563e-03*V(F1168) +8.3083113000569590e-03*V(F1169) -5.7285267685592799e-03*V(F1170) +2.8055399767804839e-03*V(F1171) -9.8010346303321178e-04*V(F1172) +9.8600012797023706e-05*V(F1173) -2.9460764146673117e+00*V(F1174) +4.6382995414593446e-03*V(F1175) -4.9214589519023131e-03*V(F1176) +6.2984103267751095e-03*V(F1177) -6.0551685163024267e-03*V(F1178) +4.1764757555444012e-03*V(F1179) -2.0466479854785017e-03*V(F1180) +7.1576111782280531e-04*V(F1181) -7.1815408167404175e-05*V(F1182) +1.6118088777676307e+00*V(F1183) -2.5646237245865637e-03*V(F1184) +2.7307969555981303e-03*V(F1185) -3.4933305182321644e-03*V(F1186) +3.3553403052119556e-03*V(F1187) -2.3109526812437500e-03*V(F1188) +1.1296879167782149e-03*V(F1189) -3.9332496293920132e-04*V(F1190) +3.9897373478641183e-05*V(F1191) -7.5326141327362173e-01*V(F1192) +1.3333374003394543e-03*V(F1193) -1.4672003656120080e-03*V(F1194) +1.8694938503485247e-03*V(F1195) -1.7804795124054809e-03*V(F1196) +1.2097656312295142e-03*V(F1197) -5.7767882415840448e-04*V(F1198) +1.9245221493162945e-04*V(F1199) -2.1676111368697834e-05*V(F1200) -1.3314691679086288e-01*V(F1201) +4.6264243737607826e-04*V(F1202) -5.8094177966210676e-04*V(F1203) +7.2939268987374693e-04*V(F1204) -6.7236059936776190e-04*V(F1205) +4.3234469706453395e-04*V(F1206) -1.8585023395901914e-04*V(F1207) +4.8559637520184640e-05*V(F1208) -8.9343477605460099e-06*V(F1209) -1.8190037986081039e-02*V(F1289) -6.7052864882392801e-02*V(F1297) +1.5174790919233896e-01*V(F1305) -1.4094674641676941e-01*V(F1313) +1.4000165801515910e-01*V(F1321) -1.0234656828182849e-01*V(F1329) +5.6004631525366701e-02*V(F1337) -2.6225389339972666e-02*V(F1345) -4.7235641707183999e-03*V(F1353) +1.1949153117574543e-01*V(F1354) -4.1341855488489820e-01*V(F1355) +9.2468337545837676e-01*V(F1356) -1.4101417980069804e+00*V(F1357) +1.5126187019712221e+00*V(F1358) -1.1987357426813869e+00*V(F1359) +1.0002034477520825e+00*V(F1360) +4.4254745871375828e-01*V(F1361) -1.5274813052303824e+00*V(F1362) +3.4130723983665883e+00*V(F1363) -5.2022669613626142e+00*V(F1364) +5.5786508662857202e+00*V(F1365) -4.4204326215321865e+00*V(F1366) +3.6928479851674609e+00*V(F1367) -1.0012390694343685e+00*V(F1368) +3.4563568245444549e+00*V(F1369) -7.7235200098464434e+00*V(F1370) +1.1772707129036281e+01*V(F1371) -1.2624699053720299e+01*V(F1372) +1.0003691345163729e+01*V(F1373) -8.3564854184944455e+00*V(F1374) +9.3082249722851018e-01*V(F1375) -3.2117827965758825e+00*V(F1376) +7.1756042117367986e+00*V(F1377) -1.0936444836980520e+01*V(F1378) +1.1727231375882143e+01*V(F1379) -9.2923028794008999e+00*V(F1380) +7.7640863127111555e+00*V(F1381) -9.2453612388226025e-01*V(F1382) +3.1901705362625399e+00*V(F1383) -7.1273928869369465e+00*V(F1384) +1.0863022981680137e+01*V(F1385) -1.1648536786780816e+01*V(F1386) +9.2299605512005698e+00*V(F1387) -7.7118989017334689e+00*V(F1388) +6.7588006181844151e-01*V(F1389) -2.3321516331709282e+00*V(F1390) +5.2104158117563779e+00*V(F1391) -7.9413029657863143e+00*V(F1392) +8.5155378018193737e+00*V(F1393) -6.7474610843454199e+00*V(F1394) +5.6377179627641647e+00*V(F1395) -3.6982558641050423e-01*V(F1396) +1.2761330440628389e+00*V(F1397) -2.8511267091185735e+00*V(F1398) +4.3454869750239054e+00*V(F1399) -4.6597247264899826e+00*V(F1400) +3.6922341835698393e+00*V(F1401) -3.0849355751264960e+00*V(F1402) +1.7307966461832094e-01*V(F1403) -5.9740857096295996e-01*V(F1404) +1.3348884109851633e+00*V(F1405) -2.0346705990329546e+00*V(F1406) +2.1818848876766053e+00*V(F1407) -1.7288923609656930e+00*V(F1408) +1.4443079512846386e+00*V(F1409) +3.1007351449485868e-02*V(F1410) -1.0731851881251726e-01*V(F1411) +2.4007300961735561e-01*V(F1412) -3.6613961522247779e-01*V(F1413) +3.9276525500558984e-01*V(F1414) -3.1126900105257577e-01*V(F1415) +2.5966917120373478e-01*V(F1416))+ ddt(( +1.0000000000000000e-03*V(Vol_F1147)));
	I(F1148)<+( -9.0337518254151544e-12*V(reduced_0) +3.7133077588484646e-10*V(reduced_1) +1.6683199287221302e-03*V(F1129) -1.9713287999449411e-03*V(F1130) +5.0384052384047232e-03*V(F1131) -5.9470857099614676e-03*V(F1132) +5.6976902291076886e-03*V(F1133) -3.9397872604870912e-03*V(F1134) +1.9256702956070833e-03*V(F1135) -6.1627578959986271e-04*V(F1136) +1.7992396063396801e-04*V(F1137) +3.3840325351479025e-03*V(F1138) -2.6017588927652508e-02*V(F1139) +3.3589779435240615e-02*V(F1140) -4.1435353178543653e-02*V(F1141) +3.9480096190084815e-02*V(F1142) -2.6941273420043748e-02*V(F1143) +1.2970072450583223e-02*V(F1144) -4.3823457796212254e-03*V(F1145) +4.9049671310531675e-04*V(F1146) -8.0505131825657737e-03*V(F1147) +5.6222507449484128e-02*V(F1148) -7.3888500000094351e-02*V(F1149) +9.1006536036037963e-02*V(F1150) -8.6728430419445890e-02*V(F1151) +5.9210607096586446e-02*V(F1152) -2.8520323008622939e-02*V(F1153) +9.6185239631264661e-03*V(F1154) -1.1345358740341691e-03*V(F1155) +6.3434130087959761e-03*V(F1156) -5.9909196730990627e-02*V(F1157) +7.4786761627320231e-02*V(F1158) -9.2529872196083177e-02*V(F1159) +8.8131507724781316e-02*V(F1160) -6.0088039907121318e-02*V(F1161) +2.8897860127007402e-02*V(F1162) -9.7993187533107120e-03*V(F1163) +9.8294915895124333e-04*V(F1164) -6.3608429840875105e-03*V(F1165) +5.9100958204148284e-02*V(F1166) -7.3959715950498661e-02*V(F1167) +9.1486378393341700e-02*V(F1168) -8.7139965788628496e-02*V(F1169) +5.9415895750492755e-02*V(F1170) -2.8576791617488967e-02*V(F1171) +9.6878521453888193e-03*V(F1172) -9.8010346304182186e-04*V(F1173) +4.6382995414549601e-03*V(F1174) -4.3284517882056464e-02*V(F1175) +5.4131016361090696e-02*V(F1176) -6.6962728732887555e-02*V(F1177) +6.3780945108477080e-02*V(F1178) -4.3487915252783643e-02*V(F1179) +2.0915608775975553e-02*V(F1180) -7.0911342288006701e-03*V(F1181) +7.1576111782908295e-04*V(F1182) -2.5646237245827578e-03*V(F1183) +2.3505747721558157e-02*V(F1184) -2.9476815163312665e-02*V(F1185) +3.6455293115218348e-02*V(F1186) -3.4724135635336210e-02*V(F1187) +2.3677766605118056e-02*V(F1188) -1.1388842563917723e-02*V(F1189) +3.8600722089994219e-03*V(F1190) -3.9332496294255042e-04*V(F1191) +1.3333374003332941e-03*V(F1192) -1.0109493354966631e-02*V(F1193) +1.3084309436002112e-02*V(F1194) -1.6136915961971587e-02*V(F1195) +1.5375852633603727e-02*V(F1196) -1.0493177901369680e-02*V(F1197) +5.0520056368631395e-03*V(F1198) -1.7065300159822530e-03*V(F1199) +1.9245221493293445e-04*V(F1200) +4.6264243738070265e-04*V(F1201) -3.1248944501624428e-04*V(F1202) +1.1486540959523169e-03*V(F1203) -1.3368026069072519e-03*V(F1204) +1.2830574247824310e-03*V(F1205) -8.9100511502867934e-04*V(F1206) +4.3760864886749503e-04*V(F1207) -1.3758649432906629e-04*V(F1208) +4.8559637520636678e-05*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1148)));
	I(F1149)<+( +1.4237978420762412e-12*V(reduced_0) -5.8524959243834797e-11*V(reduced_1) -2.0759261374266929e-03*V(F1129) +5.0384052383839325e-03*V(F1130) -9.6034097868915435e-03*V(F1131) +1.4123535683524462e-02*V(F1132) -1.3753688703412896e-02*V(F1133) +1.0108249650133584e-02*V(F1134) -5.4096085231384820e-03*V(F1135) +1.9256702956195919e-03*V(F1136) -6.7404527485215781e-04*V(F1137) -3.7156944677108387e-03*V(F1138) +3.3589779435259350e-02*V(F1139) -6.9313932751524240e-02*V(F1140) +8.3769573040749709e-02*V(F1141) -8.2182665248299813e-02*V(F1142) +6.0279049525292762e-02*V(F1143) -3.2531640025070627e-02*V(F1144) +1.2970072450618023e-02*V(F1145) -1.4678004621715513e-03*V(F1146) +8.9670834713065639e-03*V(F1147) -7.3888500000094351e-02*V(F1148) +1.5205736848290735e-01*V(F1149) -1.8508486418513739e-01*V(F1150) +1.8152521197766233e-01*V(F1151) -1.3315504617764917e-01*V(F1152) +7.1837794959406814e-02*V(F1153) -2.8520323008702900e-02*V(F1154) +3.4659468185401711e-03*V(F1155) -6.7146425906864831e-03*V(F1156) +7.4786761627311307e-02*V(F1157) -1.5513993604325216e-01*V(F1158) +1.8491178919439097e-01*V(F1159) -1.8151383819904887e-01*V(F1160) +1.3311535383455703e-01*V(F1161) -7.1887074895007202e-02*V(F1162) +2.8897860127077530e-02*V(F1163) -2.8022831515795640e-03*V(F1164) +6.7549686937256924e-03*V(F1165) -7.3959715950490584e-02*V(F1166) +1.5336441129968492e-01*V(F1167) -1.8298447695871767e-01*V(F1168) +1.7961415719296628e-01*V(F1169) -1.3172373965225290e-01*V(F1170) +7.1132080298361322e-02*V(F1171) -2.8576791617559077e-02*V(F1172) +2.8055399768241937e-03*V(F1173) -4.9214589518963439e-03*V(F1174) +5.4131016361084507e-02*V(F1175) -1.1225896008143096e-01*V(F1176) +1.3390301071430005e-01*V(F1177) -1.3143823067708071e-01*V(F1178) +9.6392630129946630e-02*V(F1179) -5.2053624314956068e-02*V(F1180) +2.0915608776026707e-02*V(F1181) -2.0466479855103773e-03*V(F1182) +2.7307969555928954e-03*V(F1183) -2.9476815163308110e-02*V(F1184) +6.1103574428658186e-02*V(F1185) -7.2968481606869570e-02*V(F1186) +7.1621883380463741e-02*V(F1187) -5.2525900789936172e-02*V(F1188) +2.8363320320655368e-02*V(F1189) -1.1388842563945494e-02*V(F1190) +1.1296879167952743e-03*V(F1191) -1.4672003656034461e-03*V(F1192) +1.3084309435996005e-02*V(F1193) -2.6989671281109694e-02*V(F1194) +3.2651302407829347e-02*V(F1195) -3.2031430201970815e-02*V(F1196) +2.3494563860711904e-02*V(F1197) -1.2679045030160256e-02*V(F1198) +5.0520056368756876e-03*V(F1199) -5.7767882416524493e-04*V(F1200) -5.8094177966852621e-04*V(F1201) +1.1486540959570130e-03*V(F1202) -2.1331166577134883e-03*V(F1203) +3.3303652293918237e-03*V(F1204) -3.2367015538074290e-03*V(F1205) +2.3800946269850920e-03*V(F1206) -1.2708543266740611e-03*V(F1207) +4.3760864887143724e-04*V(F1208) -1.8585023396130131e-04*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1149)));
	I(F1150)<+( -1.6103644558343163e-11*V(reduced_0) +6.6193747005536433e-10*V(reduced_1) +2.6089078611074021e-03*V(F1129) -5.9470857099384686e-03*V(F1130) +1.4123535683509800e-02*V(F1131) -1.9835138797072025e-02*V(F1132) +2.2196482777221933e-02*V(F1133) -1.7242346714005770e-02*V(F1134) +1.0108249650170570e-02*V(F1135) -3.9397872605262457e-03*V(F1136) +1.5557397178699553e-03*V(F1137) +4.7357248186084425e-03*V(F1138) -4.1435353178565039e-02*V(F1139) +8.3769573040761464e-02*V(F1140) -1.2690035181612747e-01*V(F1141) +1.2856298971432889e-01*V(F1142) -1.0093697659591100e-01*V(F1143) +6.0279049525411604e-02*V(F1144) -2.6941273420157334e-02*V(F1145) +3.0689899442785302e-03*V(F1146) -1.1409439419892035e-02*V(F1147) +9.1006536036037963e-02*V(F1148) -1.8508486418513739e-01*V(F1149) +2.7956493372699065e-01*V(F1150) -2.8432591819288389e-01*V(F1151) +2.2313267880440105e-01*V(F1152) -1.3315504617792071e-01*V(F1153) +5.9210607096846932e-02*V(F1154) -7.3233679284837212e-03*V(F1155) +8.5958069067546914e-03*V(F1156) -9.2529872196072366e-02*V(F1157) +1.8491178919438683e-01*V(F1158) -2.8171907172948540e-01*V(F1159) +2.8325376264271512e-01*V(F1160) -2.2257662458995006e-01*V(F1161) +1.3311535383480291e-01*V(F1162) -6.0088039907352078e-02*V(F1163) +5.7090100369724568e-03*V(F1164) -8.6440003321453761e-03*V(F1165) +9.1486378393332110e-02*V(F1166) -1.8298447695871345e-01*V(F1167) +2.7866400660580420e-01*V(F1168) -2.8034107902894084e-01*V(F1169) +2.2027381382912120e-01*V(F1170) -1.3172373965249762e-01*V(F1171) +5.9415895750723161e-02*V(F1172) -5.7285267686708026e-03*V(F1173) +6.2984103267676181e-03*V(F1174) -6.6962728732880242e-02*V(F1175) +1.3390301071429697e-01*V(F1176) -2.0394195612198343e-01*V(F1177) +2.0513812047586907e-01*V(F1178) -1.6118697220180217e-01*V(F1179) +9.6392630130125417e-02*V(F1180) -4.3487915252951828e-02*V(F1181) +4.1764757556257328e-03*V(F1182) -3.4933305182255751e-03*V(F1183) +3.6455293115212679e-02*V(F1184) -7.2968481606867822e-02*V(F1185) +1.1108251867001329e-01*V(F1186) -1.1180458656623028e-01*V(F1187) +8.7844049495371432e-02*V(F1188) -5.2525900790033997e-02*V(F1189) +2.3677766605209531e-02*V(F1190) -2.3109526812873306e-03*V(F1191) +1.8694938503377213e-03*V(F1192) -1.6136915961963597e-02*V(F1193) +3.2651302407827910e-02*V(F1194) -4.9442250096188620e-02*V(F1195) +5.0117461524121526e-02*V(F1196) -3.9345658811018244e-02*V(F1197) +2.3494563860757919e-02*V(F1198) -1.0493177901411410e-02*V(F1199) +1.2097656312471589e-03*V(F1200) +7.2939268988184483e-04*V(F1201) -1.3368026069133555e-03*V(F1202) +3.3303652293930172e-03*V(F1203) -4.5787544542798993e-03*V(F1204) +5.2668379834618292e-03*V(F1205) -4.0799434022169246e-03*V(F1206) +2.3800946269951326e-03*V(F1207) -8.9100511504062150e-04*V(F1208) +4.3234469707033378e-04*V(F1209))+ ddt(( +1.0000000000000000e-03*V(Vol_F1150)));
